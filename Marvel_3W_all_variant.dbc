VERSION ""

BA_DEF_ SG_ "CSV_ORDER" INT 0 10000;
BA_DEF_DEF_ "CSV_ORDER" 0;

NS_ :

BS_:

BU_:

BO_ 1571 BMS_Status: 8 Vector__XXX
 SG_ GPIO_Peripherals : 7|16@0+ (1,0) [0|65535] "" Vector__XXX

VAL_ 1571 GPIO_Peripherals 0 "ALL_OFF" 1 "(THROTTLE_GPIO)_ON" 2 "(AR_PUMP)_ON" 3 "(THROTTLE_GPIO+AR_PUMP)_ON" 4 "(HEATING_ELEM2)_ON" 5 "(THROTTLE_GPIO+HEATING_ELEM2)_ON" 6 "(AR_PUMP+HEATING_ELEM2)_ON" 7 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2)_ON" 8 "(AR_EN)_ON" 9 "(THROTTLE_GPIO+AR_EN)_ON" 10 "(AR_PUMP+AR_EN)_ON" 11 "(THROTTLE_GPIO+AR_PUMP+AR_EN)_ON" 12 "(HEATING_ELEM2+AR_EN)_ON" 13 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN)_ON" 14 "(AR_PUMP+HEATING_ELEM2+AR_EN)_ON" 15 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN)_ON" 16 "(AR_FAN)_ON" 17 "(THROTTLE_GPIO+AR_FAN)_ON" 18 "(AR_PUMP+AR_FAN)_ON" 19 "(THROTTLE_GPIO+AR_PUMP+AR_FAN)_ON" 20 "(HEATING_ELEM2+AR_FAN)_ON" 21 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN)_ON" 22 "(AR_PUMP+HEATING_ELEM2+AR_FAN)_ON" 23 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN)_ON" 24 "(AR_EN+AR_FAN)_ON" 25 "(THROTTLE_GPIO+AR_EN+AR_FAN)_ON" 26 "(AR_PUMP+AR_EN+AR_FAN)_ON" 27 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN)_ON" 28 "(HEATING_ELEM2+AR_EN+AR_FAN)_ON" 29 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN)_ON" 30 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN)_ON" 31 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN)_ON" 32 "(HEATING_ELEM1)_ON" 33 "(THROTTLE_GPIO+HEATING_ELEM1)_ON" 34 "(AR_PUMP+HEATING_ELEM1)_ON" 35 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1)_ON" 36 "(HEATING_ELEM2+HEATING_ELEM1)_ON" 37 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1)_ON" 38 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1)_ON" 39 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1)_ON" 40 "(AR_EN+HEATING_ELEM1)_ON" 41 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1)_ON" 42 "(AR_PUMP+AR_EN+HEATING_ELEM1)_ON" 43 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1)_ON" 44 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1)_ON" 45 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1)_ON" 46 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1)_ON" 47 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1)_ON" 48 "(AR_FAN+HEATING_ELEM1)_ON" 49 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1)_ON" 50 "(AR_PUMP+AR_FAN+HEATING_ELEM1)_ON" 51 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1)_ON" 52 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1)_ON" 53 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1)_ON" 54 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1)_ON" 55 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1)_ON" 56 "(AR_EN+AR_FAN+HEATING_ELEM1)_ON" 57 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 58 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 59 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 60 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 61 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 62 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 63 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1)_ON" 64 "(BMS_EN)_ON" 65 "(THROTTLE_GPIO+BMS_EN)_ON" 66 "(AR_PUMP+BMS_EN)_ON" 67 "(THROTTLE_GPIO+AR_PUMP+BMS_EN)_ON" 68 "(HEATING_ELEM2+BMS_EN)_ON" 69 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN)_ON" 70 "(AR_PUMP+HEATING_ELEM2+BMS_EN)_ON" 71 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN)_ON" 72 "(AR_EN+BMS_EN)_ON" 73 "(THROTTLE_GPIO+AR_EN+BMS_EN)_ON" 74 "(AR_PUMP+AR_EN+BMS_EN)_ON" 75 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN)_ON" 76 "(HEATING_ELEM2+AR_EN+BMS_EN)_ON" 77 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN)_ON" 78 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN)_ON" 79 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN)_ON" 80 "(AR_FAN+BMS_EN)_ON" 81 "(THROTTLE_GPIO+AR_FAN+BMS_EN)_ON" 82 "(AR_PUMP+AR_FAN+BMS_EN)_ON" 83 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN)_ON" 84 "(HEATING_ELEM2+AR_FAN+BMS_EN)_ON" 85 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN)_ON" 86 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN)_ON" 87 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN)_ON" 88 "(AR_EN+AR_FAN+BMS_EN)_ON" 89 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN)_ON" 90 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN)_ON" 91 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN)_ON" 92 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN)_ON" 93 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN)_ON" 94 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN)_ON" 95 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN)_ON" 96 "(HEATING_ELEM1+BMS_EN)_ON" 97 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN)_ON" 98 "(AR_PUMP+HEATING_ELEM1+BMS_EN)_ON" 99 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN)_ON" 100 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN)_ON" 101 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN)_ON" 102 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN)_ON" 103 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN)_ON" 104 "(AR_EN+HEATING_ELEM1+BMS_EN)_ON" 105 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 106 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 107 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 108 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 109 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 110 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 111 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN)_ON" 112 "(AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 113 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 114 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 115 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 116 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 117 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 118 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 119 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 120 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 121 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 122 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 123 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 124 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 125 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 126 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 127 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN)_ON" 128 "(BMS_LD)_ON" 129 "(THROTTLE_GPIO+BMS_LD)_ON" 130 "(AR_PUMP+BMS_LD)_ON" 131 "(THROTTLE_GPIO+AR_PUMP+BMS_LD)_ON" 132 "(HEATING_ELEM2+BMS_LD)_ON" 133 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD)_ON" 134 "(AR_PUMP+HEATING_ELEM2+BMS_LD)_ON" 135 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD)_ON" 136 "(AR_EN+BMS_LD)_ON" 137 "(THROTTLE_GPIO+AR_EN+BMS_LD)_ON" 138 "(AR_PUMP+AR_EN+BMS_LD)_ON" 139 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD)_ON" 140 "(HEATING_ELEM2+AR_EN+BMS_LD)_ON" 141 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD)_ON" 142 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD)_ON" 143 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD)_ON" 144 "(AR_FAN+BMS_LD)_ON" 145 "(THROTTLE_GPIO+AR_FAN+BMS_LD)_ON" 146 "(AR_PUMP+AR_FAN+BMS_LD)_ON" 147 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD)_ON" 148 "(HEATING_ELEM2+AR_FAN+BMS_LD)_ON" 149 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD)_ON" 150 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD)_ON" 151 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD)_ON" 152 "(AR_EN+AR_FAN+BMS_LD)_ON" 153 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD)_ON" 154 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD)_ON" 155 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD)_ON" 156 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD)_ON" 157 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD)_ON" 158 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD)_ON" 159 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD)_ON" 160 "(HEATING_ELEM1+BMS_LD)_ON" 161 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD)_ON" 162 "(AR_PUMP+HEATING_ELEM1+BMS_LD)_ON" 163 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD)_ON" 164 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD)_ON" 165 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD)_ON" 166 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD)_ON" 167 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD)_ON" 168 "(AR_EN+HEATING_ELEM1+BMS_LD)_ON" 169 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 170 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 171 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 172 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 173 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 174 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 175 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD)_ON" 176 "(AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 177 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 178 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 179 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 180 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 181 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 182 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 183 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 184 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 185 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 186 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 187 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 188 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 189 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 190 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 191 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD)_ON" 192 "(BMS_EN+BMS_LD)_ON" 193 "(THROTTLE_GPIO+BMS_EN+BMS_LD)_ON" 194 "(AR_PUMP+BMS_EN+BMS_LD)_ON" 195 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD)_ON" 196 "(HEATING_ELEM2+BMS_EN+BMS_LD)_ON" 197 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD)_ON" 198 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD)_ON" 199 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD)_ON" 200 "(AR_EN+BMS_EN+BMS_LD)_ON" 201 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD)_ON" 202 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD)_ON" 203 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD)_ON" 204 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD)_ON" 205 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD)_ON" 206 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD)_ON" 207 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD)_ON" 208 "(AR_FAN+BMS_EN+BMS_LD)_ON" 209 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD)_ON" 210 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD)_ON" 211 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD)_ON" 212 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD)_ON" 213 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD)_ON" 214 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD)_ON" 215 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD)_ON" 216 "(AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 217 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 218 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 219 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 220 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 221 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 222 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 223 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD)_ON" 224 "(HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 225 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 226 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 227 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 228 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 229 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 230 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 231 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 232 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 233 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 234 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 235 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 236 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 237 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 238 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 239 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 240 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 241 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 242 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 243 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 244 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 245 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 246 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 247 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 248 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 249 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 250 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 251 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 252 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 253 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 254 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 255 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD)_ON" 256 "(CHR_CONT)_ON" 257 "(THROTTLE_GPIO+CHR_CONT)_ON" 258 "(AR_PUMP+CHR_CONT)_ON" 259 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT)_ON" 260 "(HEATING_ELEM2+CHR_CONT)_ON" 261 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT)_ON" 262 "(AR_PUMP+HEATING_ELEM2+CHR_CONT)_ON" 263 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT)_ON" 264 "(AR_EN+CHR_CONT)_ON" 265 "(THROTTLE_GPIO+AR_EN+CHR_CONT)_ON" 266 "(AR_PUMP+AR_EN+CHR_CONT)_ON" 267 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT)_ON" 268 "(HEATING_ELEM2+AR_EN+CHR_CONT)_ON" 269 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT)_ON" 270 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT)_ON" 271 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT)_ON" 272 "(AR_FAN+CHR_CONT)_ON" 273 "(THROTTLE_GPIO+AR_FAN+CHR_CONT)_ON" 274 "(AR_PUMP+AR_FAN+CHR_CONT)_ON" 275 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT)_ON" 276 "(HEATING_ELEM2+AR_FAN+CHR_CONT)_ON" 277 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT)_ON" 278 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT)_ON" 279 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT)_ON" 280 "(AR_EN+AR_FAN+CHR_CONT)_ON" 281 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT)_ON" 282 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT)_ON" 283 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT)_ON" 284 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT)_ON" 285 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT)_ON" 286 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT)_ON" 287 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT)_ON" 288 "(HEATING_ELEM1+CHR_CONT)_ON" 289 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT)_ON" 290 "(AR_PUMP+HEATING_ELEM1+CHR_CONT)_ON" 291 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT)_ON" 292 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT)_ON" 293 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT)_ON" 294 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT)_ON" 295 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT)_ON" 296 "(AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 297 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 298 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 299 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 300 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 301 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 302 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 303 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT)_ON" 304 "(AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 305 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 306 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 307 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 308 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 309 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 310 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 311 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 312 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 313 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 314 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 315 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 316 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 317 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 318 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 319 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT)_ON" 320 "(BMS_EN+CHR_CONT)_ON" 321 "(THROTTLE_GPIO+BMS_EN+CHR_CONT)_ON" 322 "(AR_PUMP+BMS_EN+CHR_CONT)_ON" 323 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT)_ON" 324 "(HEATING_ELEM2+BMS_EN+CHR_CONT)_ON" 325 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT)_ON" 326 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT)_ON" 327 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT)_ON" 328 "(AR_EN+BMS_EN+CHR_CONT)_ON" 329 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT)_ON" 330 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT)_ON" 331 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT)_ON" 332 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT)_ON" 333 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT)_ON" 334 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT)_ON" 335 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT)_ON" 336 "(AR_FAN+BMS_EN+CHR_CONT)_ON" 337 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT)_ON" 338 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT)_ON" 339 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT)_ON" 340 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT)_ON" 341 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT)_ON" 342 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT)_ON" 343 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT)_ON" 344 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 345 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 346 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 347 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 348 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 349 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 350 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 351 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT)_ON" 352 "(HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 353 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 354 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 355 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 356 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 357 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 358 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 359 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 360 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 361 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 362 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 363 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 364 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 365 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 366 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 367 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 368 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 369 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 370 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 371 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 372 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 373 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 374 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 375 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 376 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 377 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 378 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 379 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 380 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 381 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 382 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 383 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT)_ON" 384 "(BMS_LD+CHR_CONT)_ON" 385 "(THROTTLE_GPIO+BMS_LD+CHR_CONT)_ON" 386 "(AR_PUMP+BMS_LD+CHR_CONT)_ON" 387 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT)_ON" 388 "(HEATING_ELEM2+BMS_LD+CHR_CONT)_ON" 389 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT)_ON" 390 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT)_ON" 391 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT)_ON" 392 "(AR_EN+BMS_LD+CHR_CONT)_ON" 393 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT)_ON" 394 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT)_ON" 395 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT)_ON" 396 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT)_ON" 397 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT)_ON" 398 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT)_ON" 399 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT)_ON" 400 "(AR_FAN+BMS_LD+CHR_CONT)_ON" 401 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT)_ON" 402 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT)_ON" 403 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT)_ON" 404 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT)_ON" 405 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT)_ON" 406 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT)_ON" 407 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT)_ON" 408 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 409 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 410 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 411 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 412 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 413 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 414 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 415 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT)_ON" 416 "(HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 417 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 418 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 419 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 420 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 421 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 422 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 423 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 424 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 425 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 426 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 427 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 428 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 429 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 430 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 431 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 432 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 433 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 434 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 435 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 436 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 437 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 438 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 439 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 440 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 441 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 442 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 443 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 444 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 445 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 446 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 447 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT)_ON" 448 "(BMS_EN+BMS_LD+CHR_CONT)_ON" 449 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT)_ON" 450 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT)_ON" 451 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT)_ON" 452 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT)_ON" 453 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT)_ON" 454 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT)_ON" 455 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT)_ON" 456 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 457 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 458 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 459 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 460 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 461 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 462 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 463 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT)_ON" 464 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 465 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 466 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 467 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 468 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 469 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 470 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 471 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 472 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 473 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 474 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 475 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 476 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 477 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 478 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 479 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT)_ON" 480 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 481 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 482 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 483 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 484 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 485 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 486 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 487 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 488 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 489 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 490 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 491 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 492 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 493 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 494 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 495 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 496 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 497 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 498 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 499 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 500 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 501 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 502 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 503 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 504 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 505 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 506 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 507 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 508 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 509 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 510 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 511 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT)_ON" 512 "(FC_CONT)_ON" 513 "(THROTTLE_GPIO+FC_CONT)_ON" 514 "(AR_PUMP+FC_CONT)_ON" 515 "(THROTTLE_GPIO+AR_PUMP+FC_CONT)_ON" 516 "(HEATING_ELEM2+FC_CONT)_ON" 517 "(THROTTLE_GPIO+HEATING_ELEM2+FC_CONT)_ON" 518 "(AR_PUMP+HEATING_ELEM2+FC_CONT)_ON" 519 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+FC_CONT)_ON" 520 "(AR_EN+FC_CONT)_ON" 521 "(THROTTLE_GPIO+AR_EN+FC_CONT)_ON" 522 "(AR_PUMP+AR_EN+FC_CONT)_ON" 523 "(THROTTLE_GPIO+AR_PUMP+AR_EN+FC_CONT)_ON" 524 "(HEATING_ELEM2+AR_EN+FC_CONT)_ON" 525 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+FC_CONT)_ON" 526 "(AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT)_ON" 527 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT)_ON" 528 "(AR_FAN+FC_CONT)_ON" 529 "(THROTTLE_GPIO+AR_FAN+FC_CONT)_ON" 530 "(AR_PUMP+AR_FAN+FC_CONT)_ON" 531 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+FC_CONT)_ON" 532 "(HEATING_ELEM2+AR_FAN+FC_CONT)_ON" 533 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+FC_CONT)_ON" 534 "(AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT)_ON" 535 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT)_ON" 536 "(AR_EN+AR_FAN+FC_CONT)_ON" 537 "(THROTTLE_GPIO+AR_EN+AR_FAN+FC_CONT)_ON" 538 "(AR_PUMP+AR_EN+AR_FAN+FC_CONT)_ON" 539 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+FC_CONT)_ON" 540 "(HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT)_ON" 541 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT)_ON" 542 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT)_ON" 543 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT)_ON" 544 "(HEATING_ELEM1+FC_CONT)_ON" 545 "(THROTTLE_GPIO+HEATING_ELEM1+FC_CONT)_ON" 546 "(AR_PUMP+HEATING_ELEM1+FC_CONT)_ON" 547 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+FC_CONT)_ON" 548 "(HEATING_ELEM2+HEATING_ELEM1+FC_CONT)_ON" 549 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+FC_CONT)_ON" 550 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT)_ON" 551 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT)_ON" 552 "(AR_EN+HEATING_ELEM1+FC_CONT)_ON" 553 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 554 "(AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 555 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 556 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 557 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 558 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 559 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT)_ON" 560 "(AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 561 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 562 "(AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 563 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 564 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 565 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 566 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 567 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 568 "(AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 569 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 570 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 571 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 572 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 573 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 574 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 575 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT)_ON" 576 "(BMS_EN+FC_CONT)_ON" 577 "(THROTTLE_GPIO+BMS_EN+FC_CONT)_ON" 578 "(AR_PUMP+BMS_EN+FC_CONT)_ON" 579 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+FC_CONT)_ON" 580 "(HEATING_ELEM2+BMS_EN+FC_CONT)_ON" 581 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+FC_CONT)_ON" 582 "(AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT)_ON" 583 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT)_ON" 584 "(AR_EN+BMS_EN+FC_CONT)_ON" 585 "(THROTTLE_GPIO+AR_EN+BMS_EN+FC_CONT)_ON" 586 "(AR_PUMP+AR_EN+BMS_EN+FC_CONT)_ON" 587 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+FC_CONT)_ON" 588 "(HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT)_ON" 589 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT)_ON" 590 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT)_ON" 591 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT)_ON" 592 "(AR_FAN+BMS_EN+FC_CONT)_ON" 593 "(THROTTLE_GPIO+AR_FAN+BMS_EN+FC_CONT)_ON" 594 "(AR_PUMP+AR_FAN+BMS_EN+FC_CONT)_ON" 595 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+FC_CONT)_ON" 596 "(HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT)_ON" 597 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT)_ON" 598 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT)_ON" 599 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT)_ON" 600 "(AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 601 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 602 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 603 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 604 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 605 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 606 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 607 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT)_ON" 608 "(HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 609 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 610 "(AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 611 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 612 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 613 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 614 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 615 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 616 "(AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 617 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 618 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 619 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 620 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 621 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 622 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 623 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 624 "(AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 625 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 626 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 627 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 628 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 629 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 630 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 631 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 632 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 633 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 634 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 635 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 636 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 637 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 638 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 639 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT)_ON" 640 "(BMS_LD+FC_CONT)_ON" 641 "(THROTTLE_GPIO+BMS_LD+FC_CONT)_ON" 642 "(AR_PUMP+BMS_LD+FC_CONT)_ON" 643 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+FC_CONT)_ON" 644 "(HEATING_ELEM2+BMS_LD+FC_CONT)_ON" 645 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+FC_CONT)_ON" 646 "(AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT)_ON" 647 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT)_ON" 648 "(AR_EN+BMS_LD+FC_CONT)_ON" 649 "(THROTTLE_GPIO+AR_EN+BMS_LD+FC_CONT)_ON" 650 "(AR_PUMP+AR_EN+BMS_LD+FC_CONT)_ON" 651 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+FC_CONT)_ON" 652 "(HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT)_ON" 653 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT)_ON" 654 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT)_ON" 655 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT)_ON" 656 "(AR_FAN+BMS_LD+FC_CONT)_ON" 657 "(THROTTLE_GPIO+AR_FAN+BMS_LD+FC_CONT)_ON" 658 "(AR_PUMP+AR_FAN+BMS_LD+FC_CONT)_ON" 659 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+FC_CONT)_ON" 660 "(HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT)_ON" 661 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT)_ON" 662 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT)_ON" 663 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT)_ON" 664 "(AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 665 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 666 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 667 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 668 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 669 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 670 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 671 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT)_ON" 672 "(HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 673 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 674 "(AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 675 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 676 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 677 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 678 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 679 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 680 "(AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 681 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 682 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 683 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 684 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 685 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 686 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 687 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 688 "(AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 689 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 690 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 691 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 692 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 693 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 694 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 695 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 696 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 697 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 698 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 699 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 700 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 701 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 702 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 703 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT)_ON" 704 "(BMS_EN+BMS_LD+FC_CONT)_ON" 705 "(THROTTLE_GPIO+BMS_EN+BMS_LD+FC_CONT)_ON" 706 "(AR_PUMP+BMS_EN+BMS_LD+FC_CONT)_ON" 707 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+FC_CONT)_ON" 708 "(HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT)_ON" 709 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT)_ON" 710 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT)_ON" 711 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT)_ON" 712 "(AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 713 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 714 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 715 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 716 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 717 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 718 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 719 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT)_ON" 720 "(AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 721 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 722 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 723 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 724 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 725 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 726 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 727 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 728 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 729 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 730 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 731 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 732 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 733 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 734 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 735 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT)_ON" 736 "(HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 737 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 738 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 739 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 740 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 741 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 742 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 743 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 744 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 745 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 746 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 747 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 748 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 749 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 750 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 751 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 752 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 753 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 754 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 755 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 756 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 757 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 758 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 759 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 760 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 761 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 762 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 763 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 764 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 765 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 766 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 767 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT)_ON" 768 "(CHR_CONT+FC_CONT)_ON" 769 "(THROTTLE_GPIO+CHR_CONT+FC_CONT)_ON" 770 "(AR_PUMP+CHR_CONT+FC_CONT)_ON" 771 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+FC_CONT)_ON" 772 "(HEATING_ELEM2+CHR_CONT+FC_CONT)_ON" 773 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+FC_CONT)_ON" 774 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT)_ON" 775 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT)_ON" 776 "(AR_EN+CHR_CONT+FC_CONT)_ON" 777 "(THROTTLE_GPIO+AR_EN+CHR_CONT+FC_CONT)_ON" 778 "(AR_PUMP+AR_EN+CHR_CONT+FC_CONT)_ON" 779 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+FC_CONT)_ON" 780 "(HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT)_ON" 781 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT)_ON" 782 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT)_ON" 783 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT)_ON" 784 "(AR_FAN+CHR_CONT+FC_CONT)_ON" 785 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+FC_CONT)_ON" 786 "(AR_PUMP+AR_FAN+CHR_CONT+FC_CONT)_ON" 787 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+FC_CONT)_ON" 788 "(HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT)_ON" 789 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT)_ON" 790 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT)_ON" 791 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT)_ON" 792 "(AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 793 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 794 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 795 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 796 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 797 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 798 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 799 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT)_ON" 800 "(HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 801 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 802 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 803 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 804 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 805 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 806 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 807 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 808 "(AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 809 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 810 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 811 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 812 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 813 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 814 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 815 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 816 "(AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 817 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 818 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 819 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 820 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 821 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 822 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 823 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 824 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 825 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 826 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 827 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 828 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 829 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 830 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 831 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT)_ON" 832 "(BMS_EN+CHR_CONT+FC_CONT)_ON" 833 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+FC_CONT)_ON" 834 "(AR_PUMP+BMS_EN+CHR_CONT+FC_CONT)_ON" 835 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+FC_CONT)_ON" 836 "(HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT)_ON" 837 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT)_ON" 838 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT)_ON" 839 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT)_ON" 840 "(AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 841 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 842 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 843 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 844 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 845 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 846 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 847 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT)_ON" 848 "(AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 849 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 850 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 851 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 852 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 853 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 854 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 855 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 856 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 857 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 858 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 859 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 860 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 861 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 862 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 863 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT)_ON" 864 "(HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 865 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 866 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 867 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 868 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 869 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 870 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 871 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 872 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 873 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 874 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 875 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 876 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 877 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 878 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 879 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 880 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 881 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 882 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 883 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 884 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 885 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 886 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 887 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 888 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 889 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 890 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 891 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 892 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 893 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 894 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 895 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT)_ON" 896 "(BMS_LD+CHR_CONT+FC_CONT)_ON" 897 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+FC_CONT)_ON" 898 "(AR_PUMP+BMS_LD+CHR_CONT+FC_CONT)_ON" 899 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+FC_CONT)_ON" 900 "(HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT)_ON" 901 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT)_ON" 902 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT)_ON" 903 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT)_ON" 904 "(AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 905 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 906 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 907 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 908 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 909 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 910 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 911 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 912 "(AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 913 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 914 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 915 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 916 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 917 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 918 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 919 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 920 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 921 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 922 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 923 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 924 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 925 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 926 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 927 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT)_ON" 928 "(HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 929 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 930 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 931 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 932 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 933 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 934 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 935 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 936 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 937 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 938 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 939 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 940 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 941 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 942 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 943 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 944 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 945 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 946 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 947 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 948 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 949 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 950 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 951 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 952 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 953 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 954 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 955 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 956 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 957 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 958 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 959 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT)_ON" 960 "(BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 961 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 962 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 963 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 964 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 965 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 966 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 967 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 968 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 969 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 970 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 971 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 972 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 973 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 974 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 975 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 976 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 977 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 978 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 979 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 980 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 981 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 982 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 983 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 984 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 985 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 986 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 987 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 988 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 989 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 990 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 991 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 992 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 993 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 994 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 995 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 996 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 997 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 998 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 999 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1000 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1001 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1002 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1003 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1004 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1005 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1006 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1007 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1008 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1009 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1010 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1011 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1012 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1013 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1014 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1015 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1016 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1017 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1018 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1019 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1020 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1021 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1022 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1023 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT)_ON" 1024 "(DCDC)_ON" 1025 "(THROTTLE_GPIO+DCDC)_ON" 1026 "(AR_PUMP+DCDC)_ON" 1027 "(THROTTLE_GPIO+AR_PUMP+DCDC)_ON" 1028 "(HEATING_ELEM2+DCDC)_ON" 1029 "(THROTTLE_GPIO+HEATING_ELEM2+DCDC)_ON" 1030 "(AR_PUMP+HEATING_ELEM2+DCDC)_ON" 1031 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+DCDC)_ON" 1032 "(AR_EN+DCDC)_ON" 1033 "(THROTTLE_GPIO+AR_EN+DCDC)_ON" 1034 "(AR_PUMP+AR_EN+DCDC)_ON" 1035 "(THROTTLE_GPIO+AR_PUMP+AR_EN+DCDC)_ON" 1036 "(HEATING_ELEM2+AR_EN+DCDC)_ON" 1037 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+DCDC)_ON" 1038 "(AR_PUMP+HEATING_ELEM2+AR_EN+DCDC)_ON" 1039 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+DCDC)_ON" 1040 "(AR_FAN+DCDC)_ON" 1041 "(THROTTLE_GPIO+AR_FAN+DCDC)_ON" 1042 "(AR_PUMP+AR_FAN+DCDC)_ON" 1043 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+DCDC)_ON" 1044 "(HEATING_ELEM2+AR_FAN+DCDC)_ON" 1045 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+DCDC)_ON" 1046 "(AR_PUMP+HEATING_ELEM2+AR_FAN+DCDC)_ON" 1047 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+DCDC)_ON" 1048 "(AR_EN+AR_FAN+DCDC)_ON" 1049 "(THROTTLE_GPIO+AR_EN+AR_FAN+DCDC)_ON" 1050 "(AR_PUMP+AR_EN+AR_FAN+DCDC)_ON" 1051 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+DCDC)_ON" 1052 "(HEATING_ELEM2+AR_EN+AR_FAN+DCDC)_ON" 1053 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+DCDC)_ON" 1054 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+DCDC)_ON" 1055 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+DCDC)_ON" 1056 "(HEATING_ELEM1+DCDC)_ON" 1057 "(THROTTLE_GPIO+HEATING_ELEM1+DCDC)_ON" 1058 "(AR_PUMP+HEATING_ELEM1+DCDC)_ON" 1059 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+DCDC)_ON" 1060 "(HEATING_ELEM2+HEATING_ELEM1+DCDC)_ON" 1061 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+DCDC)_ON" 1062 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+DCDC)_ON" 1063 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+DCDC)_ON" 1064 "(AR_EN+HEATING_ELEM1+DCDC)_ON" 1065 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+DCDC)_ON" 1066 "(AR_PUMP+AR_EN+HEATING_ELEM1+DCDC)_ON" 1067 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+DCDC)_ON" 1068 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC)_ON" 1069 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC)_ON" 1070 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC)_ON" 1071 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC)_ON" 1072 "(AR_FAN+HEATING_ELEM1+DCDC)_ON" 1073 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1074 "(AR_PUMP+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1075 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1076 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1077 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1078 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1079 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1080 "(AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1081 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1082 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1083 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1084 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1085 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1086 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1087 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC)_ON" 1088 "(BMS_EN+DCDC)_ON" 1089 "(THROTTLE_GPIO+BMS_EN+DCDC)_ON" 1090 "(AR_PUMP+BMS_EN+DCDC)_ON" 1091 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+DCDC)_ON" 1092 "(HEATING_ELEM2+BMS_EN+DCDC)_ON" 1093 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+DCDC)_ON" 1094 "(AR_PUMP+HEATING_ELEM2+BMS_EN+DCDC)_ON" 1095 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+DCDC)_ON" 1096 "(AR_EN+BMS_EN+DCDC)_ON" 1097 "(THROTTLE_GPIO+AR_EN+BMS_EN+DCDC)_ON" 1098 "(AR_PUMP+AR_EN+BMS_EN+DCDC)_ON" 1099 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+DCDC)_ON" 1100 "(HEATING_ELEM2+AR_EN+BMS_EN+DCDC)_ON" 1101 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+DCDC)_ON" 1102 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+DCDC)_ON" 1103 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+DCDC)_ON" 1104 "(AR_FAN+BMS_EN+DCDC)_ON" 1105 "(THROTTLE_GPIO+AR_FAN+BMS_EN+DCDC)_ON" 1106 "(AR_PUMP+AR_FAN+BMS_EN+DCDC)_ON" 1107 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+DCDC)_ON" 1108 "(HEATING_ELEM2+AR_FAN+BMS_EN+DCDC)_ON" 1109 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC)_ON" 1110 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC)_ON" 1111 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC)_ON" 1112 "(AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1113 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1114 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1115 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1116 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1117 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1118 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1119 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC)_ON" 1120 "(HEATING_ELEM1+BMS_EN+DCDC)_ON" 1121 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1122 "(AR_PUMP+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1123 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1124 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1125 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1126 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1127 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1128 "(AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1129 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1130 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1131 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1132 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1133 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1134 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1135 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1136 "(AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1137 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1138 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1139 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1140 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1141 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1142 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1143 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1144 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1145 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1146 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1147 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1148 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1149 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1150 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1151 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC)_ON" 1152 "(BMS_LD+DCDC)_ON" 1153 "(THROTTLE_GPIO+BMS_LD+DCDC)_ON" 1154 "(AR_PUMP+BMS_LD+DCDC)_ON" 1155 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+DCDC)_ON" 1156 "(HEATING_ELEM2+BMS_LD+DCDC)_ON" 1157 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+DCDC)_ON" 1158 "(AR_PUMP+HEATING_ELEM2+BMS_LD+DCDC)_ON" 1159 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+DCDC)_ON" 1160 "(AR_EN+BMS_LD+DCDC)_ON" 1161 "(THROTTLE_GPIO+AR_EN+BMS_LD+DCDC)_ON" 1162 "(AR_PUMP+AR_EN+BMS_LD+DCDC)_ON" 1163 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+DCDC)_ON" 1164 "(HEATING_ELEM2+AR_EN+BMS_LD+DCDC)_ON" 1165 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+DCDC)_ON" 1166 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+DCDC)_ON" 1167 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+DCDC)_ON" 1168 "(AR_FAN+BMS_LD+DCDC)_ON" 1169 "(THROTTLE_GPIO+AR_FAN+BMS_LD+DCDC)_ON" 1170 "(AR_PUMP+AR_FAN+BMS_LD+DCDC)_ON" 1171 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+DCDC)_ON" 1172 "(HEATING_ELEM2+AR_FAN+BMS_LD+DCDC)_ON" 1173 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC)_ON" 1174 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC)_ON" 1175 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC)_ON" 1176 "(AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1177 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1178 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1179 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1180 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1181 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1182 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1183 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC)_ON" 1184 "(HEATING_ELEM1+BMS_LD+DCDC)_ON" 1185 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1186 "(AR_PUMP+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1187 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1188 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1189 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1190 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1191 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1192 "(AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1193 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1194 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1195 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1196 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1197 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1198 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1199 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1200 "(AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1201 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1202 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1203 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1204 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1205 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1206 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1207 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1208 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1209 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1210 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1211 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1212 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1213 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1214 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1215 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC)_ON" 1216 "(BMS_EN+BMS_LD+DCDC)_ON" 1217 "(THROTTLE_GPIO+BMS_EN+BMS_LD+DCDC)_ON" 1218 "(AR_PUMP+BMS_EN+BMS_LD+DCDC)_ON" 1219 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+DCDC)_ON" 1220 "(HEATING_ELEM2+BMS_EN+BMS_LD+DCDC)_ON" 1221 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC)_ON" 1222 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC)_ON" 1223 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC)_ON" 1224 "(AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1225 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1226 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1227 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1228 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1229 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1230 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1231 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC)_ON" 1232 "(AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1233 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1234 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1235 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1236 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1237 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1238 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1239 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1240 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1241 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1242 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1243 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1244 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1245 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1246 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1247 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC)_ON" 1248 "(HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1249 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1250 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1251 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1252 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1253 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1254 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1255 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1256 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1257 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1258 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1259 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1260 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1261 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1262 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1263 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1264 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1265 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1266 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1267 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1268 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1269 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1270 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1271 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1272 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1273 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1274 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1275 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1276 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1277 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1278 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1279 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC)_ON" 1280 "(CHR_CONT+DCDC)_ON" 1281 "(THROTTLE_GPIO+CHR_CONT+DCDC)_ON" 1282 "(AR_PUMP+CHR_CONT+DCDC)_ON" 1283 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+DCDC)_ON" 1284 "(HEATING_ELEM2+CHR_CONT+DCDC)_ON" 1285 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+DCDC)_ON" 1286 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+DCDC)_ON" 1287 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+DCDC)_ON" 1288 "(AR_EN+CHR_CONT+DCDC)_ON" 1289 "(THROTTLE_GPIO+AR_EN+CHR_CONT+DCDC)_ON" 1290 "(AR_PUMP+AR_EN+CHR_CONT+DCDC)_ON" 1291 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+DCDC)_ON" 1292 "(HEATING_ELEM2+AR_EN+CHR_CONT+DCDC)_ON" 1293 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC)_ON" 1294 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC)_ON" 1295 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC)_ON" 1296 "(AR_FAN+CHR_CONT+DCDC)_ON" 1297 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+DCDC)_ON" 1298 "(AR_PUMP+AR_FAN+CHR_CONT+DCDC)_ON" 1299 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+DCDC)_ON" 1300 "(HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC)_ON" 1301 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC)_ON" 1302 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC)_ON" 1303 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC)_ON" 1304 "(AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1305 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1306 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1307 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1308 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1309 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1310 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1311 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC)_ON" 1312 "(HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1313 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1314 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1315 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1316 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1317 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1318 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1319 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1320 "(AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1321 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1322 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1323 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1324 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1325 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1326 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1327 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1328 "(AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1329 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1330 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1331 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1332 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1333 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1334 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1335 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1336 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1337 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1338 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1339 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1340 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1341 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1342 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1343 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC)_ON" 1344 "(BMS_EN+CHR_CONT+DCDC)_ON" 1345 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+DCDC)_ON" 1346 "(AR_PUMP+BMS_EN+CHR_CONT+DCDC)_ON" 1347 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+DCDC)_ON" 1348 "(HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC)_ON" 1349 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC)_ON" 1350 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC)_ON" 1351 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC)_ON" 1352 "(AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1353 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1354 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1355 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1356 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1357 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1358 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1359 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC)_ON" 1360 "(AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1361 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1362 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1363 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1364 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1365 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1366 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1367 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1368 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1369 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1370 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1371 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1372 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1373 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1374 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1375 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC)_ON" 1376 "(HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1377 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1378 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1379 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1380 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1381 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1382 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1383 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1384 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1385 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1386 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1387 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1388 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1389 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1390 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1391 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1392 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1393 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1394 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1395 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1396 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1397 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1398 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1399 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1400 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1401 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1402 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1403 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1404 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1405 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1406 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1407 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC)_ON" 1408 "(BMS_LD+CHR_CONT+DCDC)_ON" 1409 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+DCDC)_ON" 1410 "(AR_PUMP+BMS_LD+CHR_CONT+DCDC)_ON" 1411 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+DCDC)_ON" 1412 "(HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC)_ON" 1413 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC)_ON" 1414 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC)_ON" 1415 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC)_ON" 1416 "(AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1417 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1418 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1419 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1420 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1421 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1422 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1423 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1424 "(AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1425 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1426 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1427 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1428 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1429 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1430 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1431 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1432 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1433 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1434 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1435 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1436 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1437 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1438 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1439 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC)_ON" 1440 "(HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1441 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1442 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1443 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1444 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1445 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1446 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1447 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1448 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1449 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1450 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1451 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1452 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1453 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1454 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1455 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1456 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1457 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1458 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1459 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1460 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1461 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1462 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1463 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1464 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1465 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1466 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1467 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1468 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1469 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1470 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1471 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC)_ON" 1472 "(BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1473 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1474 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1475 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1476 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1477 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1478 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1479 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1480 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1481 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1482 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1483 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1484 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1485 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1486 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1487 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1488 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1489 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1490 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1491 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1492 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1493 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1494 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1495 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1496 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1497 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1498 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1499 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1500 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1501 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1502 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1503 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1504 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1505 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1506 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1507 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1508 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1509 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1510 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1511 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1512 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1513 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1514 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1515 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1516 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1517 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1518 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1519 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1520 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1521 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1522 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1523 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1524 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1525 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1526 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1527 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1528 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1529 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1530 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1531 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1532 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1533 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1534 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1535 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC)_ON" 1536 "(FC_CONT+DCDC)_ON" 1537 "(THROTTLE_GPIO+FC_CONT+DCDC)_ON" 1538 "(AR_PUMP+FC_CONT+DCDC)_ON" 1539 "(THROTTLE_GPIO+AR_PUMP+FC_CONT+DCDC)_ON" 1540 "(HEATING_ELEM2+FC_CONT+DCDC)_ON" 1541 "(THROTTLE_GPIO+HEATING_ELEM2+FC_CONT+DCDC)_ON" 1542 "(AR_PUMP+HEATING_ELEM2+FC_CONT+DCDC)_ON" 1543 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+FC_CONT+DCDC)_ON" 1544 "(AR_EN+FC_CONT+DCDC)_ON" 1545 "(THROTTLE_GPIO+AR_EN+FC_CONT+DCDC)_ON" 1546 "(AR_PUMP+AR_EN+FC_CONT+DCDC)_ON" 1547 "(THROTTLE_GPIO+AR_PUMP+AR_EN+FC_CONT+DCDC)_ON" 1548 "(HEATING_ELEM2+AR_EN+FC_CONT+DCDC)_ON" 1549 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+FC_CONT+DCDC)_ON" 1550 "(AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+DCDC)_ON" 1551 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+DCDC)_ON" 1552 "(AR_FAN+FC_CONT+DCDC)_ON" 1553 "(THROTTLE_GPIO+AR_FAN+FC_CONT+DCDC)_ON" 1554 "(AR_PUMP+AR_FAN+FC_CONT+DCDC)_ON" 1555 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+FC_CONT+DCDC)_ON" 1556 "(HEATING_ELEM2+AR_FAN+FC_CONT+DCDC)_ON" 1557 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC)_ON" 1558 "(AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC)_ON" 1559 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC)_ON" 1560 "(AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1561 "(THROTTLE_GPIO+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1562 "(AR_PUMP+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1563 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1564 "(HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1565 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1566 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1567 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC)_ON" 1568 "(HEATING_ELEM1+FC_CONT+DCDC)_ON" 1569 "(THROTTLE_GPIO+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1570 "(AR_PUMP+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1571 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1572 "(HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1573 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1574 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1575 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1576 "(AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1577 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1578 "(AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1579 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1580 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1581 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1582 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1583 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1584 "(AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1585 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1586 "(AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1587 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1588 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1589 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1590 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1591 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1592 "(AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1593 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1594 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1595 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1596 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1597 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1598 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1599 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC)_ON" 1600 "(BMS_EN+FC_CONT+DCDC)_ON" 1601 "(THROTTLE_GPIO+BMS_EN+FC_CONT+DCDC)_ON" 1602 "(AR_PUMP+BMS_EN+FC_CONT+DCDC)_ON" 1603 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+FC_CONT+DCDC)_ON" 1604 "(HEATING_ELEM2+BMS_EN+FC_CONT+DCDC)_ON" 1605 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC)_ON" 1606 "(AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC)_ON" 1607 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC)_ON" 1608 "(AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1609 "(THROTTLE_GPIO+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1610 "(AR_PUMP+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1611 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1612 "(HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1613 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1614 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1615 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC)_ON" 1616 "(AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1617 "(THROTTLE_GPIO+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1618 "(AR_PUMP+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1619 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1620 "(HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1621 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1622 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1623 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1624 "(AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1625 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1626 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1627 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1628 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1629 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1630 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1631 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC)_ON" 1632 "(HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1633 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1634 "(AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1635 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1636 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1637 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1638 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1639 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1640 "(AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1641 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1642 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1643 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1644 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1645 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1646 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1647 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1648 "(AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1649 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1650 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1651 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1652 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1653 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1654 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1655 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1656 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1657 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1658 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1659 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1660 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1661 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1662 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1663 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC)_ON" 1664 "(BMS_LD+FC_CONT+DCDC)_ON" 1665 "(THROTTLE_GPIO+BMS_LD+FC_CONT+DCDC)_ON" 1666 "(AR_PUMP+BMS_LD+FC_CONT+DCDC)_ON" 1667 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+FC_CONT+DCDC)_ON" 1668 "(HEATING_ELEM2+BMS_LD+FC_CONT+DCDC)_ON" 1669 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC)_ON" 1670 "(AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC)_ON" 1671 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC)_ON" 1672 "(AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1673 "(THROTTLE_GPIO+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1674 "(AR_PUMP+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1675 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1676 "(HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1677 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1678 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1679 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC)_ON" 1680 "(AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1681 "(THROTTLE_GPIO+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1682 "(AR_PUMP+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1683 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1684 "(HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1685 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1686 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1687 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1688 "(AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1689 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1690 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1691 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1692 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1693 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1694 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1695 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC)_ON" 1696 "(HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1697 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1698 "(AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1699 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1700 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1701 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1702 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1703 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1704 "(AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1705 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1706 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1707 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1708 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1709 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1710 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1711 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1712 "(AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1713 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1714 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1715 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1716 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1717 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1718 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1719 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1720 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1721 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1722 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1723 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1724 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1725 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1726 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1727 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC)_ON" 1728 "(BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1729 "(THROTTLE_GPIO+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1730 "(AR_PUMP+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1731 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1732 "(HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1733 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1734 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1735 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1736 "(AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1737 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1738 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1739 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1740 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1741 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1742 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1743 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1744 "(AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1745 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1746 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1747 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1748 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1749 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1750 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1751 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1752 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1753 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1754 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1755 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1756 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1757 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1758 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1759 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1760 "(HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1761 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1762 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1763 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1764 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1765 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1766 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1767 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1768 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1769 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1770 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1771 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1772 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1773 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1774 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1775 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1776 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1777 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1778 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1779 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1780 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1781 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1782 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1783 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1784 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1785 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1786 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1787 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1788 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1789 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1790 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1791 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC)_ON" 1792 "(CHR_CONT+FC_CONT+DCDC)_ON" 1793 "(THROTTLE_GPIO+CHR_CONT+FC_CONT+DCDC)_ON" 1794 "(AR_PUMP+CHR_CONT+FC_CONT+DCDC)_ON" 1795 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+FC_CONT+DCDC)_ON" 1796 "(HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC)_ON" 1797 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC)_ON" 1798 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC)_ON" 1799 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC)_ON" 1800 "(AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1801 "(THROTTLE_GPIO+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1802 "(AR_PUMP+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1803 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1804 "(HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1805 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1806 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1807 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1808 "(AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1809 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1810 "(AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1811 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1812 "(HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1813 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1814 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1815 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1816 "(AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1817 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1818 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1819 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1820 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1821 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1822 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1823 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC)_ON" 1824 "(HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1825 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1826 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1827 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1828 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1829 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1830 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1831 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1832 "(AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1833 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1834 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1835 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1836 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1837 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1838 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1839 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1840 "(AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1841 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1842 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1843 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1844 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1845 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1846 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1847 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1848 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1849 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1850 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1851 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1852 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1853 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1854 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1855 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC)_ON" 1856 "(BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1857 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1858 "(AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1859 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1860 "(HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1861 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1862 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1863 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1864 "(AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1865 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1866 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1867 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1868 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1869 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1870 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1871 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1872 "(AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1873 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1874 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1875 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1876 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1877 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1878 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1879 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1880 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1881 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1882 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1883 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1884 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1885 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1886 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1887 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1888 "(HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1889 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1890 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1891 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1892 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1893 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1894 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1895 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1896 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1897 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1898 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1899 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1900 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1901 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1902 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1903 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1904 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1905 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1906 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1907 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1908 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1909 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1910 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1911 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1912 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1913 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1914 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1915 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1916 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1917 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1918 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1919 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC)_ON" 1920 "(BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1921 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1922 "(AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1923 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1924 "(HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1925 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1926 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1927 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1928 "(AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1929 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1930 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1931 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1932 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1933 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1934 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1935 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1936 "(AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1937 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1938 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1939 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1940 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1941 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1942 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1943 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1944 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1945 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1946 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1947 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1948 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1949 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1950 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1951 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1952 "(HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1953 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1954 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1955 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1956 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1957 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1958 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1959 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1960 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1961 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1962 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1963 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1964 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1965 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1966 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1967 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1968 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1969 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1970 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1971 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1972 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1973 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1974 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1975 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1976 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1977 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1978 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1979 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1980 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1981 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1982 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1983 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1984 "(BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1985 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1986 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1987 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1988 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1989 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1990 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1991 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1992 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1993 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1994 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1995 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1996 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1997 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1998 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 1999 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2000 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2001 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2002 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2003 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2004 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2005 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2006 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2007 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2008 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2009 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2010 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2011 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2012 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2013 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2014 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2015 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2016 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2017 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2018 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2019 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2020 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2021 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2022 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2023 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2024 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2025 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2026 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2027 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2028 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2029 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2030 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2031 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2032 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2033 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2034 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2035 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2036 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2037 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2038 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2039 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2040 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2041 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2042 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2043 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2044 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2045 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2046 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2047 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC)_ON" 2048 "(MCU_FAN)_ON" 2049 "(THROTTLE_GPIO+MCU_FAN)_ON" 2050 "(AR_PUMP+MCU_FAN)_ON" 2051 "(THROTTLE_GPIO+AR_PUMP+MCU_FAN)_ON" 2052 "(HEATING_ELEM2+MCU_FAN)_ON" 2053 "(THROTTLE_GPIO+HEATING_ELEM2+MCU_FAN)_ON" 2054 "(AR_PUMP+HEATING_ELEM2+MCU_FAN)_ON" 2055 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+MCU_FAN)_ON" 2056 "(AR_EN+MCU_FAN)_ON" 2057 "(THROTTLE_GPIO+AR_EN+MCU_FAN)_ON" 2058 "(AR_PUMP+AR_EN+MCU_FAN)_ON" 2059 "(THROTTLE_GPIO+AR_PUMP+AR_EN+MCU_FAN)_ON" 2060 "(HEATING_ELEM2+AR_EN+MCU_FAN)_ON" 2061 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+MCU_FAN)_ON" 2062 "(AR_PUMP+HEATING_ELEM2+AR_EN+MCU_FAN)_ON" 2063 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+MCU_FAN)_ON" 2064 "(AR_FAN+MCU_FAN)_ON" 2065 "(THROTTLE_GPIO+AR_FAN+MCU_FAN)_ON" 2066 "(AR_PUMP+AR_FAN+MCU_FAN)_ON" 2067 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+MCU_FAN)_ON" 2068 "(HEATING_ELEM2+AR_FAN+MCU_FAN)_ON" 2069 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+MCU_FAN)_ON" 2070 "(AR_PUMP+HEATING_ELEM2+AR_FAN+MCU_FAN)_ON" 2071 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+MCU_FAN)_ON" 2072 "(AR_EN+AR_FAN+MCU_FAN)_ON" 2073 "(THROTTLE_GPIO+AR_EN+AR_FAN+MCU_FAN)_ON" 2074 "(AR_PUMP+AR_EN+AR_FAN+MCU_FAN)_ON" 2075 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+MCU_FAN)_ON" 2076 "(HEATING_ELEM2+AR_EN+AR_FAN+MCU_FAN)_ON" 2077 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+MCU_FAN)_ON" 2078 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+MCU_FAN)_ON" 2079 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+MCU_FAN)_ON" 2080 "(HEATING_ELEM1+MCU_FAN)_ON" 2081 "(THROTTLE_GPIO+HEATING_ELEM1+MCU_FAN)_ON" 2082 "(AR_PUMP+HEATING_ELEM1+MCU_FAN)_ON" 2083 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+MCU_FAN)_ON" 2084 "(HEATING_ELEM2+HEATING_ELEM1+MCU_FAN)_ON" 2085 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+MCU_FAN)_ON" 2086 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+MCU_FAN)_ON" 2087 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+MCU_FAN)_ON" 2088 "(AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2089 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2090 "(AR_PUMP+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2091 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2092 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2093 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2094 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2095 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+MCU_FAN)_ON" 2096 "(AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2097 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2098 "(AR_PUMP+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2099 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2100 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2101 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2102 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2103 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2104 "(AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2105 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2106 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2107 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2108 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2109 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2110 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2111 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+MCU_FAN)_ON" 2112 "(BMS_EN+MCU_FAN)_ON" 2113 "(THROTTLE_GPIO+BMS_EN+MCU_FAN)_ON" 2114 "(AR_PUMP+BMS_EN+MCU_FAN)_ON" 2115 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+MCU_FAN)_ON" 2116 "(HEATING_ELEM2+BMS_EN+MCU_FAN)_ON" 2117 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+MCU_FAN)_ON" 2118 "(AR_PUMP+HEATING_ELEM2+BMS_EN+MCU_FAN)_ON" 2119 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+MCU_FAN)_ON" 2120 "(AR_EN+BMS_EN+MCU_FAN)_ON" 2121 "(THROTTLE_GPIO+AR_EN+BMS_EN+MCU_FAN)_ON" 2122 "(AR_PUMP+AR_EN+BMS_EN+MCU_FAN)_ON" 2123 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+MCU_FAN)_ON" 2124 "(HEATING_ELEM2+AR_EN+BMS_EN+MCU_FAN)_ON" 2125 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+MCU_FAN)_ON" 2126 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+MCU_FAN)_ON" 2127 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+MCU_FAN)_ON" 2128 "(AR_FAN+BMS_EN+MCU_FAN)_ON" 2129 "(THROTTLE_GPIO+AR_FAN+BMS_EN+MCU_FAN)_ON" 2130 "(AR_PUMP+AR_FAN+BMS_EN+MCU_FAN)_ON" 2131 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+MCU_FAN)_ON" 2132 "(HEATING_ELEM2+AR_FAN+BMS_EN+MCU_FAN)_ON" 2133 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+MCU_FAN)_ON" 2134 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+MCU_FAN)_ON" 2135 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+MCU_FAN)_ON" 2136 "(AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2137 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2138 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2139 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2140 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2141 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2142 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2143 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+MCU_FAN)_ON" 2144 "(HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2145 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2146 "(AR_PUMP+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2147 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2148 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2149 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2150 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2151 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2152 "(AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2153 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2154 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2155 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2156 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2157 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2158 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2159 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2160 "(AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2161 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2162 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2163 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2164 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2165 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2166 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2167 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2168 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2169 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2170 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2171 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2172 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2173 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2174 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2175 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+MCU_FAN)_ON" 2176 "(BMS_LD+MCU_FAN)_ON" 2177 "(THROTTLE_GPIO+BMS_LD+MCU_FAN)_ON" 2178 "(AR_PUMP+BMS_LD+MCU_FAN)_ON" 2179 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+MCU_FAN)_ON" 2180 "(HEATING_ELEM2+BMS_LD+MCU_FAN)_ON" 2181 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+MCU_FAN)_ON" 2182 "(AR_PUMP+HEATING_ELEM2+BMS_LD+MCU_FAN)_ON" 2183 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+MCU_FAN)_ON" 2184 "(AR_EN+BMS_LD+MCU_FAN)_ON" 2185 "(THROTTLE_GPIO+AR_EN+BMS_LD+MCU_FAN)_ON" 2186 "(AR_PUMP+AR_EN+BMS_LD+MCU_FAN)_ON" 2187 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+MCU_FAN)_ON" 2188 "(HEATING_ELEM2+AR_EN+BMS_LD+MCU_FAN)_ON" 2189 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+MCU_FAN)_ON" 2190 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+MCU_FAN)_ON" 2191 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+MCU_FAN)_ON" 2192 "(AR_FAN+BMS_LD+MCU_FAN)_ON" 2193 "(THROTTLE_GPIO+AR_FAN+BMS_LD+MCU_FAN)_ON" 2194 "(AR_PUMP+AR_FAN+BMS_LD+MCU_FAN)_ON" 2195 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+MCU_FAN)_ON" 2196 "(HEATING_ELEM2+AR_FAN+BMS_LD+MCU_FAN)_ON" 2197 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+MCU_FAN)_ON" 2198 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+MCU_FAN)_ON" 2199 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+MCU_FAN)_ON" 2200 "(AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2201 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2202 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2203 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2204 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2205 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2206 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2207 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+MCU_FAN)_ON" 2208 "(HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2209 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2210 "(AR_PUMP+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2211 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2212 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2213 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2214 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2215 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2216 "(AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2217 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2218 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2219 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2220 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2221 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2222 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2223 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2224 "(AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2225 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2226 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2227 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2228 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2229 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2230 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2231 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2232 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2233 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2234 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2235 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2236 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2237 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2238 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2239 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+MCU_FAN)_ON" 2240 "(BMS_EN+BMS_LD+MCU_FAN)_ON" 2241 "(THROTTLE_GPIO+BMS_EN+BMS_LD+MCU_FAN)_ON" 2242 "(AR_PUMP+BMS_EN+BMS_LD+MCU_FAN)_ON" 2243 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+MCU_FAN)_ON" 2244 "(HEATING_ELEM2+BMS_EN+BMS_LD+MCU_FAN)_ON" 2245 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+MCU_FAN)_ON" 2246 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+MCU_FAN)_ON" 2247 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+MCU_FAN)_ON" 2248 "(AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2249 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2250 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2251 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2252 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2253 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2254 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2255 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2256 "(AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2257 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2258 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2259 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2260 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2261 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2262 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2263 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2264 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2265 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2266 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2267 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2268 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2269 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2270 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2271 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+MCU_FAN)_ON" 2272 "(HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2273 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2274 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2275 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2276 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2277 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2278 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2279 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2280 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2281 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2282 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2283 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2284 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2285 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2286 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2287 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2288 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2289 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2290 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2291 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2292 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2293 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2294 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2295 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2296 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2297 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2298 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2299 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2300 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2301 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2302 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2303 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+MCU_FAN)_ON" 2304 "(CHR_CONT+MCU_FAN)_ON" 2305 "(THROTTLE_GPIO+CHR_CONT+MCU_FAN)_ON" 2306 "(AR_PUMP+CHR_CONT+MCU_FAN)_ON" 2307 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+MCU_FAN)_ON" 2308 "(HEATING_ELEM2+CHR_CONT+MCU_FAN)_ON" 2309 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+MCU_FAN)_ON" 2310 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+MCU_FAN)_ON" 2311 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+MCU_FAN)_ON" 2312 "(AR_EN+CHR_CONT+MCU_FAN)_ON" 2313 "(THROTTLE_GPIO+AR_EN+CHR_CONT+MCU_FAN)_ON" 2314 "(AR_PUMP+AR_EN+CHR_CONT+MCU_FAN)_ON" 2315 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+MCU_FAN)_ON" 2316 "(HEATING_ELEM2+AR_EN+CHR_CONT+MCU_FAN)_ON" 2317 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+MCU_FAN)_ON" 2318 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+MCU_FAN)_ON" 2319 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+MCU_FAN)_ON" 2320 "(AR_FAN+CHR_CONT+MCU_FAN)_ON" 2321 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2322 "(AR_PUMP+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2323 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2324 "(HEATING_ELEM2+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2325 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2326 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2327 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2328 "(AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2329 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2330 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2331 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2332 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2333 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2334 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2335 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+MCU_FAN)_ON" 2336 "(HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2337 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2338 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2339 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2340 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2341 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2342 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2343 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2344 "(AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2345 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2346 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2347 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2348 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2349 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2350 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2351 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2352 "(AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2353 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2354 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2355 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2356 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2357 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2358 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2359 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2360 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2361 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2362 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2363 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2364 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2365 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2366 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2367 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+MCU_FAN)_ON" 2368 "(BMS_EN+CHR_CONT+MCU_FAN)_ON" 2369 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2370 "(AR_PUMP+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2371 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2372 "(HEATING_ELEM2+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2373 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2374 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2375 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2376 "(AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2377 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2378 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2379 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2380 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2381 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2382 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2383 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2384 "(AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2385 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2386 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2387 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2388 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2389 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2390 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2391 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2392 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2393 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2394 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2395 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2396 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2397 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2398 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2399 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2400 "(HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2401 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2402 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2403 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2404 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2405 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2406 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2407 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2408 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2409 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2410 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2411 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2412 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2413 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2414 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2415 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2416 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2417 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2418 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2419 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2420 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2421 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2422 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2423 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2424 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2425 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2426 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2427 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2428 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2429 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2430 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2431 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+MCU_FAN)_ON" 2432 "(BMS_LD+CHR_CONT+MCU_FAN)_ON" 2433 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2434 "(AR_PUMP+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2435 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2436 "(HEATING_ELEM2+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2437 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2438 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2439 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2440 "(AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2441 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2442 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2443 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2444 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2445 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2446 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2447 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2448 "(AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2449 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2450 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2451 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2452 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2453 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2454 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2455 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2456 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2457 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2458 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2459 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2460 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2461 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2462 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2463 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2464 "(HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2465 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2466 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2467 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2468 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2469 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2470 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2471 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2472 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2473 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2474 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2475 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2476 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2477 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2478 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2479 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2480 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2481 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2482 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2483 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2484 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2485 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2486 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2487 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2488 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2489 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2490 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2491 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2492 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2493 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2494 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2495 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2496 "(BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2497 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2498 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2499 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2500 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2501 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2502 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2503 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2504 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2505 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2506 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2507 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2508 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2509 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2510 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2511 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2512 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2513 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2514 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2515 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2516 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2517 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2518 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2519 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2520 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2521 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2522 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2523 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2524 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2525 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2526 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2527 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2528 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2529 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2530 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2531 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2532 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2533 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2534 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2535 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2536 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2537 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2538 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2539 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2540 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2541 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2542 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2543 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2544 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2545 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2546 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2547 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2548 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2549 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2550 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2551 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2552 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2553 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2554 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2555 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2556 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2557 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2558 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2559 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+MCU_FAN)_ON" 2560 "(FC_CONT+MCU_FAN)_ON" 2561 "(THROTTLE_GPIO+FC_CONT+MCU_FAN)_ON" 2562 "(AR_PUMP+FC_CONT+MCU_FAN)_ON" 2563 "(THROTTLE_GPIO+AR_PUMP+FC_CONT+MCU_FAN)_ON" 2564 "(HEATING_ELEM2+FC_CONT+MCU_FAN)_ON" 2565 "(THROTTLE_GPIO+HEATING_ELEM2+FC_CONT+MCU_FAN)_ON" 2566 "(AR_PUMP+HEATING_ELEM2+FC_CONT+MCU_FAN)_ON" 2567 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+FC_CONT+MCU_FAN)_ON" 2568 "(AR_EN+FC_CONT+MCU_FAN)_ON" 2569 "(THROTTLE_GPIO+AR_EN+FC_CONT+MCU_FAN)_ON" 2570 "(AR_PUMP+AR_EN+FC_CONT+MCU_FAN)_ON" 2571 "(THROTTLE_GPIO+AR_PUMP+AR_EN+FC_CONT+MCU_FAN)_ON" 2572 "(HEATING_ELEM2+AR_EN+FC_CONT+MCU_FAN)_ON" 2573 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+FC_CONT+MCU_FAN)_ON" 2574 "(AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+MCU_FAN)_ON" 2575 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+MCU_FAN)_ON" 2576 "(AR_FAN+FC_CONT+MCU_FAN)_ON" 2577 "(THROTTLE_GPIO+AR_FAN+FC_CONT+MCU_FAN)_ON" 2578 "(AR_PUMP+AR_FAN+FC_CONT+MCU_FAN)_ON" 2579 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+FC_CONT+MCU_FAN)_ON" 2580 "(HEATING_ELEM2+AR_FAN+FC_CONT+MCU_FAN)_ON" 2581 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+FC_CONT+MCU_FAN)_ON" 2582 "(AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+MCU_FAN)_ON" 2583 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+MCU_FAN)_ON" 2584 "(AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2585 "(THROTTLE_GPIO+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2586 "(AR_PUMP+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2587 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2588 "(HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2589 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2590 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2591 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+MCU_FAN)_ON" 2592 "(HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2593 "(THROTTLE_GPIO+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2594 "(AR_PUMP+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2595 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2596 "(HEATING_ELEM2+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2597 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2598 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2599 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2600 "(AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2601 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2602 "(AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2603 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2604 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2605 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2606 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2607 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2608 "(AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2609 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2610 "(AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2611 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2612 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2613 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2614 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2615 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2616 "(AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2617 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2618 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2619 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2620 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2621 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2622 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2623 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+MCU_FAN)_ON" 2624 "(BMS_EN+FC_CONT+MCU_FAN)_ON" 2625 "(THROTTLE_GPIO+BMS_EN+FC_CONT+MCU_FAN)_ON" 2626 "(AR_PUMP+BMS_EN+FC_CONT+MCU_FAN)_ON" 2627 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+FC_CONT+MCU_FAN)_ON" 2628 "(HEATING_ELEM2+BMS_EN+FC_CONT+MCU_FAN)_ON" 2629 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+FC_CONT+MCU_FAN)_ON" 2630 "(AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+MCU_FAN)_ON" 2631 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+MCU_FAN)_ON" 2632 "(AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2633 "(THROTTLE_GPIO+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2634 "(AR_PUMP+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2635 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2636 "(HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2637 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2638 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2639 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2640 "(AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2641 "(THROTTLE_GPIO+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2642 "(AR_PUMP+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2643 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2644 "(HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2645 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2646 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2647 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2648 "(AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2649 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2650 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2651 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2652 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2653 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2654 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2655 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+MCU_FAN)_ON" 2656 "(HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2657 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2658 "(AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2659 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2660 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2661 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2662 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2663 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2664 "(AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2665 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2666 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2667 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2668 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2669 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2670 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2671 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2672 "(AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2673 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2674 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2675 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2676 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2677 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2678 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2679 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2680 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2681 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2682 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2683 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2684 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2685 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2686 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2687 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+MCU_FAN)_ON" 2688 "(BMS_LD+FC_CONT+MCU_FAN)_ON" 2689 "(THROTTLE_GPIO+BMS_LD+FC_CONT+MCU_FAN)_ON" 2690 "(AR_PUMP+BMS_LD+FC_CONT+MCU_FAN)_ON" 2691 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+FC_CONT+MCU_FAN)_ON" 2692 "(HEATING_ELEM2+BMS_LD+FC_CONT+MCU_FAN)_ON" 2693 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+FC_CONT+MCU_FAN)_ON" 2694 "(AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+MCU_FAN)_ON" 2695 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+MCU_FAN)_ON" 2696 "(AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2697 "(THROTTLE_GPIO+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2698 "(AR_PUMP+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2699 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2700 "(HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2701 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2702 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2703 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2704 "(AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2705 "(THROTTLE_GPIO+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2706 "(AR_PUMP+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2707 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2708 "(HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2709 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2710 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2711 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2712 "(AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2713 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2714 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2715 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2716 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2717 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2718 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2719 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2720 "(HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2721 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2722 "(AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2723 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2724 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2725 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2726 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2727 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2728 "(AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2729 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2730 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2731 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2732 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2733 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2734 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2735 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2736 "(AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2737 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2738 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2739 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2740 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2741 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2742 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2743 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2744 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2745 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2746 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2747 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2748 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2749 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2750 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2751 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+MCU_FAN)_ON" 2752 "(BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2753 "(THROTTLE_GPIO+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2754 "(AR_PUMP+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2755 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2756 "(HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2757 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2758 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2759 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2760 "(AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2761 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2762 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2763 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2764 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2765 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2766 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2767 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2768 "(AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2769 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2770 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2771 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2772 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2773 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2774 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2775 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2776 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2777 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2778 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2779 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2780 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2781 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2782 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2783 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2784 "(HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2785 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2786 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2787 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2788 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2789 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2790 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2791 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2792 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2793 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2794 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2795 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2796 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2797 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2798 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2799 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2800 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2801 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2802 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2803 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2804 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2805 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2806 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2807 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2808 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2809 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2810 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2811 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2812 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2813 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2814 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2815 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+MCU_FAN)_ON" 2816 "(CHR_CONT+FC_CONT+MCU_FAN)_ON" 2817 "(THROTTLE_GPIO+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2818 "(AR_PUMP+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2819 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2820 "(HEATING_ELEM2+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2821 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2822 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2823 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2824 "(AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2825 "(THROTTLE_GPIO+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2826 "(AR_PUMP+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2827 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2828 "(HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2829 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2830 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2831 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2832 "(AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2833 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2834 "(AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2835 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2836 "(HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2837 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2838 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2839 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2840 "(AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2841 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2842 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2843 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2844 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2845 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2846 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2847 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2848 "(HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2849 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2850 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2851 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2852 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2853 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2854 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2855 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2856 "(AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2857 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2858 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2859 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2860 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2861 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2862 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2863 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2864 "(AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2865 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2866 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2867 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2868 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2869 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2870 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2871 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2872 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2873 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2874 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2875 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2876 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2877 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2878 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2879 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2880 "(BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2881 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2882 "(AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2883 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2884 "(HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2885 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2886 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2887 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2888 "(AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2889 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2890 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2891 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2892 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2893 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2894 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2895 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2896 "(AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2897 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2898 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2899 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2900 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2901 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2902 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2903 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2904 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2905 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2906 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2907 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2908 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2909 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2910 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2911 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2912 "(HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2913 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2914 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2915 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2916 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2917 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2918 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2919 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2920 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2921 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2922 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2923 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2924 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2925 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2926 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2927 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2928 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2929 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2930 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2931 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2932 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2933 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2934 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2935 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2936 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2937 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2938 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2939 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2940 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2941 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2942 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2943 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2944 "(BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2945 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2946 "(AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2947 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2948 "(HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2949 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2950 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2951 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2952 "(AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2953 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2954 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2955 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2956 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2957 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2958 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2959 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2960 "(AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2961 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2962 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2963 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2964 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2965 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2966 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2967 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2968 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2969 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2970 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2971 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2972 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2973 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2974 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2975 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2976 "(HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2977 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2978 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2979 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2980 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2981 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2982 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2983 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2984 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2985 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2986 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2987 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2988 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2989 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2990 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2991 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2992 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2993 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2994 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2995 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2996 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2997 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2998 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 2999 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3000 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3001 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3002 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3003 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3004 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3005 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3006 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3007 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3008 "(BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3009 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3010 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3011 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3012 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3013 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3014 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3015 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3016 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3017 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3018 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3019 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3020 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3021 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3022 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3023 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3024 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3025 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3026 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3027 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3028 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3029 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3030 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3031 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3032 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3033 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3034 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3035 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3036 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3037 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3038 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3039 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3040 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3041 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3042 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3043 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3044 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3045 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3046 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3047 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3048 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3049 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3050 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3051 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3052 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3053 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3054 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3055 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3056 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3057 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3058 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3059 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3060 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3061 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3062 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3063 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3064 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3065 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3066 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3067 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3068 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3069 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3070 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3071 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+MCU_FAN)_ON" 3072 "(DCDC+MCU_FAN)_ON" 3073 "(THROTTLE_GPIO+DCDC+MCU_FAN)_ON" 3074 "(AR_PUMP+DCDC+MCU_FAN)_ON" 3075 "(THROTTLE_GPIO+AR_PUMP+DCDC+MCU_FAN)_ON" 3076 "(HEATING_ELEM2+DCDC+MCU_FAN)_ON" 3077 "(THROTTLE_GPIO+HEATING_ELEM2+DCDC+MCU_FAN)_ON" 3078 "(AR_PUMP+HEATING_ELEM2+DCDC+MCU_FAN)_ON" 3079 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+DCDC+MCU_FAN)_ON" 3080 "(AR_EN+DCDC+MCU_FAN)_ON" 3081 "(THROTTLE_GPIO+AR_EN+DCDC+MCU_FAN)_ON" 3082 "(AR_PUMP+AR_EN+DCDC+MCU_FAN)_ON" 3083 "(THROTTLE_GPIO+AR_PUMP+AR_EN+DCDC+MCU_FAN)_ON" 3084 "(HEATING_ELEM2+AR_EN+DCDC+MCU_FAN)_ON" 3085 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+DCDC+MCU_FAN)_ON" 3086 "(AR_PUMP+HEATING_ELEM2+AR_EN+DCDC+MCU_FAN)_ON" 3087 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+DCDC+MCU_FAN)_ON" 3088 "(AR_FAN+DCDC+MCU_FAN)_ON" 3089 "(THROTTLE_GPIO+AR_FAN+DCDC+MCU_FAN)_ON" 3090 "(AR_PUMP+AR_FAN+DCDC+MCU_FAN)_ON" 3091 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+DCDC+MCU_FAN)_ON" 3092 "(HEATING_ELEM2+AR_FAN+DCDC+MCU_FAN)_ON" 3093 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+DCDC+MCU_FAN)_ON" 3094 "(AR_PUMP+HEATING_ELEM2+AR_FAN+DCDC+MCU_FAN)_ON" 3095 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+DCDC+MCU_FAN)_ON" 3096 "(AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3097 "(THROTTLE_GPIO+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3098 "(AR_PUMP+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3099 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3100 "(HEATING_ELEM2+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3101 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3102 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3103 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+DCDC+MCU_FAN)_ON" 3104 "(HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3105 "(THROTTLE_GPIO+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3106 "(AR_PUMP+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3107 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3108 "(HEATING_ELEM2+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3109 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3110 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3111 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3112 "(AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3113 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3114 "(AR_PUMP+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3115 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3116 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3117 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3118 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3119 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3120 "(AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3121 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3122 "(AR_PUMP+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3123 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3124 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3125 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3126 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3127 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3128 "(AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3129 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3130 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3131 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3132 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3133 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3134 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3135 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+MCU_FAN)_ON" 3136 "(BMS_EN+DCDC+MCU_FAN)_ON" 3137 "(THROTTLE_GPIO+BMS_EN+DCDC+MCU_FAN)_ON" 3138 "(AR_PUMP+BMS_EN+DCDC+MCU_FAN)_ON" 3139 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+DCDC+MCU_FAN)_ON" 3140 "(HEATING_ELEM2+BMS_EN+DCDC+MCU_FAN)_ON" 3141 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+DCDC+MCU_FAN)_ON" 3142 "(AR_PUMP+HEATING_ELEM2+BMS_EN+DCDC+MCU_FAN)_ON" 3143 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+DCDC+MCU_FAN)_ON" 3144 "(AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3145 "(THROTTLE_GPIO+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3146 "(AR_PUMP+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3147 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3148 "(HEATING_ELEM2+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3149 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3150 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3151 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+DCDC+MCU_FAN)_ON" 3152 "(AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3153 "(THROTTLE_GPIO+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3154 "(AR_PUMP+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3155 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3156 "(HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3157 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3158 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3159 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3160 "(AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3161 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3162 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3163 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3164 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3165 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3166 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3167 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+MCU_FAN)_ON" 3168 "(HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3169 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3170 "(AR_PUMP+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3171 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3172 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3173 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3174 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3175 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3176 "(AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3177 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3178 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3179 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3180 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3181 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3182 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3183 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3184 "(AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3185 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3186 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3187 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3188 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3189 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3190 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3191 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3192 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3193 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3194 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3195 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3196 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3197 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3198 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3199 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+MCU_FAN)_ON" 3200 "(BMS_LD+DCDC+MCU_FAN)_ON" 3201 "(THROTTLE_GPIO+BMS_LD+DCDC+MCU_FAN)_ON" 3202 "(AR_PUMP+BMS_LD+DCDC+MCU_FAN)_ON" 3203 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+DCDC+MCU_FAN)_ON" 3204 "(HEATING_ELEM2+BMS_LD+DCDC+MCU_FAN)_ON" 3205 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+DCDC+MCU_FAN)_ON" 3206 "(AR_PUMP+HEATING_ELEM2+BMS_LD+DCDC+MCU_FAN)_ON" 3207 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+DCDC+MCU_FAN)_ON" 3208 "(AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3209 "(THROTTLE_GPIO+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3210 "(AR_PUMP+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3211 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3212 "(HEATING_ELEM2+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3213 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3214 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3215 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3216 "(AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3217 "(THROTTLE_GPIO+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3218 "(AR_PUMP+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3219 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3220 "(HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3221 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3222 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3223 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3224 "(AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3225 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3226 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3227 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3228 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3229 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3230 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3231 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+MCU_FAN)_ON" 3232 "(HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3233 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3234 "(AR_PUMP+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3235 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3236 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3237 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3238 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3239 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3240 "(AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3241 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3242 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3243 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3244 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3245 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3246 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3247 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3248 "(AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3249 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3250 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3251 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3252 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3253 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3254 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3255 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3256 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3257 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3258 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3259 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3260 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3261 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3262 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3263 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+MCU_FAN)_ON" 3264 "(BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3265 "(THROTTLE_GPIO+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3266 "(AR_PUMP+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3267 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3268 "(HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3269 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3270 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3271 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3272 "(AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3273 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3274 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3275 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3276 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3277 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3278 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3279 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3280 "(AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3281 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3282 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3283 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3284 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3285 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3286 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3287 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3288 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3289 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3290 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3291 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3292 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3293 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3294 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3295 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3296 "(HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3297 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3298 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3299 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3300 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3301 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3302 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3303 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3304 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3305 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3306 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3307 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3308 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3309 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3310 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3311 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3312 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3313 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3314 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3315 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3316 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3317 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3318 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3319 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3320 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3321 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3322 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3323 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3324 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3325 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3326 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3327 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+MCU_FAN)_ON" 3328 "(CHR_CONT+DCDC+MCU_FAN)_ON" 3329 "(THROTTLE_GPIO+CHR_CONT+DCDC+MCU_FAN)_ON" 3330 "(AR_PUMP+CHR_CONT+DCDC+MCU_FAN)_ON" 3331 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+DCDC+MCU_FAN)_ON" 3332 "(HEATING_ELEM2+CHR_CONT+DCDC+MCU_FAN)_ON" 3333 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+DCDC+MCU_FAN)_ON" 3334 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+DCDC+MCU_FAN)_ON" 3335 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+DCDC+MCU_FAN)_ON" 3336 "(AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3337 "(THROTTLE_GPIO+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3338 "(AR_PUMP+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3339 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3340 "(HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3341 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3342 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3343 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3344 "(AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3345 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3346 "(AR_PUMP+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3347 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3348 "(HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3349 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3350 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3351 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3352 "(AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3353 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3354 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3355 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3356 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3357 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3358 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3359 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+MCU_FAN)_ON" 3360 "(HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3361 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3362 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3363 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3364 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3365 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3366 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3367 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3368 "(AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3369 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3370 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3371 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3372 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3373 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3374 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3375 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3376 "(AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3377 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3378 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3379 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3380 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3381 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3382 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3383 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3384 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3385 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3386 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3387 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3388 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3389 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3390 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3391 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+MCU_FAN)_ON" 3392 "(BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3393 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3394 "(AR_PUMP+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3395 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3396 "(HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3397 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3398 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3399 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3400 "(AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3401 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3402 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3403 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3404 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3405 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3406 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3407 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3408 "(AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3409 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3410 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3411 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3412 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3413 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3414 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3415 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3416 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3417 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3418 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3419 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3420 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3421 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3422 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3423 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3424 "(HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3425 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3426 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3427 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3428 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3429 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3430 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3431 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3432 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3433 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3434 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3435 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3436 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3437 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3438 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3439 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3440 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3441 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3442 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3443 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3444 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3445 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3446 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3447 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3448 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3449 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3450 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3451 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3452 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3453 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3454 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3455 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+MCU_FAN)_ON" 3456 "(BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3457 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3458 "(AR_PUMP+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3459 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3460 "(HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3461 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3462 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3463 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3464 "(AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3465 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3466 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3467 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3468 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3469 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3470 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3471 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3472 "(AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3473 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3474 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3475 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3476 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3477 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3478 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3479 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3480 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3481 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3482 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3483 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3484 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3485 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3486 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3487 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3488 "(HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3489 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3490 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3491 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3492 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3493 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3494 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3495 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3496 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3497 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3498 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3499 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3500 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3501 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3502 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3503 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3504 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3505 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3506 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3507 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3508 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3509 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3510 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3511 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3512 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3513 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3514 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3515 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3516 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3517 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3518 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3519 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3520 "(BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3521 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3522 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3523 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3524 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3525 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3526 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3527 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3528 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3529 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3530 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3531 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3532 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3533 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3534 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3535 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3536 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3537 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3538 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3539 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3540 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3541 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3542 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3543 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3544 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3545 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3546 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3547 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3548 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3549 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3550 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3551 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3552 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3553 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3554 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3555 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3556 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3557 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3558 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3559 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3560 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3561 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3562 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3563 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3564 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3565 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3566 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3567 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3568 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3569 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3570 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3571 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3572 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3573 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3574 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3575 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3576 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3577 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3578 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3579 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3580 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3581 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3582 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3583 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+MCU_FAN)_ON" 3584 "(FC_CONT+DCDC+MCU_FAN)_ON" 3585 "(THROTTLE_GPIO+FC_CONT+DCDC+MCU_FAN)_ON" 3586 "(AR_PUMP+FC_CONT+DCDC+MCU_FAN)_ON" 3587 "(THROTTLE_GPIO+AR_PUMP+FC_CONT+DCDC+MCU_FAN)_ON" 3588 "(HEATING_ELEM2+FC_CONT+DCDC+MCU_FAN)_ON" 3589 "(THROTTLE_GPIO+HEATING_ELEM2+FC_CONT+DCDC+MCU_FAN)_ON" 3590 "(AR_PUMP+HEATING_ELEM2+FC_CONT+DCDC+MCU_FAN)_ON" 3591 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+FC_CONT+DCDC+MCU_FAN)_ON" 3592 "(AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3593 "(THROTTLE_GPIO+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3594 "(AR_PUMP+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3595 "(THROTTLE_GPIO+AR_PUMP+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3596 "(HEATING_ELEM2+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3597 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3598 "(AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3599 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3600 "(AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3601 "(THROTTLE_GPIO+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3602 "(AR_PUMP+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3603 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3604 "(HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3605 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3606 "(AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3607 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3608 "(AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3609 "(THROTTLE_GPIO+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3610 "(AR_PUMP+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3611 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3612 "(HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3613 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3614 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3615 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+MCU_FAN)_ON" 3616 "(HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3617 "(THROTTLE_GPIO+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3618 "(AR_PUMP+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3619 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3620 "(HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3621 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3622 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3623 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3624 "(AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3625 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3626 "(AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3627 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3628 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3629 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3630 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3631 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3632 "(AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3633 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3634 "(AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3635 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3636 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3637 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3638 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3639 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3640 "(AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3641 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3642 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3643 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3644 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3645 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3646 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3647 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+MCU_FAN)_ON" 3648 "(BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3649 "(THROTTLE_GPIO+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3650 "(AR_PUMP+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3651 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3652 "(HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3653 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3654 "(AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3655 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3656 "(AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3657 "(THROTTLE_GPIO+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3658 "(AR_PUMP+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3659 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3660 "(HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3661 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3662 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3663 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3664 "(AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3665 "(THROTTLE_GPIO+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3666 "(AR_PUMP+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3667 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3668 "(HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3669 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3670 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3671 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3672 "(AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3673 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3674 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3675 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3676 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3677 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3678 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3679 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3680 "(HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3681 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3682 "(AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3683 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3684 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3685 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3686 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3687 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3688 "(AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3689 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3690 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3691 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3692 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3693 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3694 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3695 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3696 "(AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3697 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3698 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3699 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3700 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3701 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3702 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3703 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3704 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3705 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3706 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3707 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3708 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3709 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3710 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3711 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+MCU_FAN)_ON" 3712 "(BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3713 "(THROTTLE_GPIO+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3714 "(AR_PUMP+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3715 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3716 "(HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3717 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3718 "(AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3719 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3720 "(AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3721 "(THROTTLE_GPIO+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3722 "(AR_PUMP+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3723 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3724 "(HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3725 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3726 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3727 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3728 "(AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3729 "(THROTTLE_GPIO+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3730 "(AR_PUMP+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3731 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3732 "(HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3733 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3734 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3735 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3736 "(AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3737 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3738 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3739 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3740 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3741 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3742 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3743 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3744 "(HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3745 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3746 "(AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3747 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3748 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3749 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3750 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3751 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3752 "(AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3753 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3754 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3755 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3756 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3757 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3758 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3759 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3760 "(AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3761 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3762 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3763 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3764 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3765 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3766 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3767 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3768 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3769 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3770 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3771 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3772 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3773 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3774 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3775 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3776 "(BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3777 "(THROTTLE_GPIO+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3778 "(AR_PUMP+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3779 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3780 "(HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3781 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3782 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3783 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3784 "(AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3785 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3786 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3787 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3788 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3789 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3790 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3791 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3792 "(AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3793 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3794 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3795 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3796 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3797 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3798 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3799 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3800 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3801 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3802 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3803 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3804 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3805 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3806 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3807 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3808 "(HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3809 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3810 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3811 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3812 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3813 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3814 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3815 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3816 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3817 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3818 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3819 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3820 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3821 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3822 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3823 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3824 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3825 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3826 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3827 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3828 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3829 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3830 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3831 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3832 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3833 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3834 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3835 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3836 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3837 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3838 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3839 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+MCU_FAN)_ON" 3840 "(CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3841 "(THROTTLE_GPIO+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3842 "(AR_PUMP+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3843 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3844 "(HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3845 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3846 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3847 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3848 "(AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3849 "(THROTTLE_GPIO+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3850 "(AR_PUMP+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3851 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3852 "(HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3853 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3854 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3855 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3856 "(AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3857 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3858 "(AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3859 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3860 "(HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3861 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3862 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3863 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3864 "(AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3865 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3866 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3867 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3868 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3869 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3870 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3871 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3872 "(HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3873 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3874 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3875 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3876 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3877 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3878 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3879 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3880 "(AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3881 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3882 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3883 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3884 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3885 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3886 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3887 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3888 "(AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3889 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3890 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3891 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3892 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3893 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3894 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3895 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3896 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3897 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3898 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3899 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3900 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3901 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3902 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3903 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3904 "(BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3905 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3906 "(AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3907 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3908 "(HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3909 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3910 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3911 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3912 "(AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3913 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3914 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3915 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3916 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3917 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3918 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3919 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3920 "(AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3921 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3922 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3923 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3924 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3925 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3926 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3927 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3928 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3929 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3930 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3931 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3932 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3933 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3934 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3935 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3936 "(HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3937 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3938 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3939 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3940 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3941 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3942 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3943 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3944 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3945 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3946 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3947 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3948 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3949 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3950 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3951 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3952 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3953 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3954 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3955 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3956 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3957 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3958 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3959 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3960 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3961 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3962 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3963 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3964 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3965 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3966 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3967 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3968 "(BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3969 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3970 "(AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3971 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3972 "(HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3973 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3974 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3975 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3976 "(AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3977 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3978 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3979 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3980 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3981 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3982 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3983 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3984 "(AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3985 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3986 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3987 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3988 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3989 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3990 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3991 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3992 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3993 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3994 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3995 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3996 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3997 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3998 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 3999 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4000 "(HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4001 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4002 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4003 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4004 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4005 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4006 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4007 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4008 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4009 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4010 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4011 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4012 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4013 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4014 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4015 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4016 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4017 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4018 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4019 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4020 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4021 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4022 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4023 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4024 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4025 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4026 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4027 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4028 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4029 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4030 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4031 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4032 "(BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4033 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4034 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4035 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4036 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4037 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4038 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4039 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4040 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4041 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4042 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4043 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4044 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4045 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4046 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4047 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4048 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4049 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4050 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4051 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4052 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4053 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4054 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4055 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4056 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4057 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4058 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4059 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4060 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4061 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4062 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4063 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4064 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4065 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4066 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4067 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4068 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4069 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4070 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4071 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4072 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4073 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4074 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4075 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4076 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4077 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4078 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4079 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4080 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4081 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4082 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4083 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4084 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4085 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4086 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4087 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4088 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4089 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4090 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4091 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4092 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4093 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4094 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4095 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+MCU_FAN)_ON" 4096 "(GTEK_EN)_ON" 4097 "(THROTTLE_GPIO+GTEK_EN)_ON" 4098 "(AR_PUMP+GTEK_EN)_ON" 4099 "(THROTTLE_GPIO+AR_PUMP+GTEK_EN)_ON" 4100 "(HEATING_ELEM2+GTEK_EN)_ON" 4101 "(THROTTLE_GPIO+HEATING_ELEM2+GTEK_EN)_ON" 4102 "(AR_PUMP+HEATING_ELEM2+GTEK_EN)_ON" 4103 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+GTEK_EN)_ON" 4104 "(AR_EN+GTEK_EN)_ON" 4105 "(THROTTLE_GPIO+AR_EN+GTEK_EN)_ON" 4106 "(AR_PUMP+AR_EN+GTEK_EN)_ON" 4107 "(THROTTLE_GPIO+AR_PUMP+AR_EN+GTEK_EN)_ON" 4108 "(HEATING_ELEM2+AR_EN+GTEK_EN)_ON" 4109 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+GTEK_EN)_ON" 4110 "(AR_PUMP+HEATING_ELEM2+AR_EN+GTEK_EN)_ON" 4111 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+GTEK_EN)_ON" 4112 "(AR_FAN+GTEK_EN)_ON" 4113 "(THROTTLE_GPIO+AR_FAN+GTEK_EN)_ON" 4114 "(AR_PUMP+AR_FAN+GTEK_EN)_ON" 4115 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+GTEK_EN)_ON" 4116 "(HEATING_ELEM2+AR_FAN+GTEK_EN)_ON" 4117 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+GTEK_EN)_ON" 4118 "(AR_PUMP+HEATING_ELEM2+AR_FAN+GTEK_EN)_ON" 4119 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+GTEK_EN)_ON" 4120 "(AR_EN+AR_FAN+GTEK_EN)_ON" 4121 "(THROTTLE_GPIO+AR_EN+AR_FAN+GTEK_EN)_ON" 4122 "(AR_PUMP+AR_EN+AR_FAN+GTEK_EN)_ON" 4123 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+GTEK_EN)_ON" 4124 "(HEATING_ELEM2+AR_EN+AR_FAN+GTEK_EN)_ON" 4125 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+GTEK_EN)_ON" 4126 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+GTEK_EN)_ON" 4127 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+GTEK_EN)_ON" 4128 "(HEATING_ELEM1+GTEK_EN)_ON" 4129 "(THROTTLE_GPIO+HEATING_ELEM1+GTEK_EN)_ON" 4130 "(AR_PUMP+HEATING_ELEM1+GTEK_EN)_ON" 4131 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+GTEK_EN)_ON" 4132 "(HEATING_ELEM2+HEATING_ELEM1+GTEK_EN)_ON" 4133 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+GTEK_EN)_ON" 4134 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+GTEK_EN)_ON" 4135 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+GTEK_EN)_ON" 4136 "(AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4137 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4138 "(AR_PUMP+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4139 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4140 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4141 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4142 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4143 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+GTEK_EN)_ON" 4144 "(AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4145 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4146 "(AR_PUMP+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4147 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4148 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4149 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4150 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4151 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4152 "(AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4153 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4154 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4155 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4156 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4157 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4158 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4159 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+GTEK_EN)_ON" 4160 "(BMS_EN+GTEK_EN)_ON" 4161 "(THROTTLE_GPIO+BMS_EN+GTEK_EN)_ON" 4162 "(AR_PUMP+BMS_EN+GTEK_EN)_ON" 4163 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+GTEK_EN)_ON" 4164 "(HEATING_ELEM2+BMS_EN+GTEK_EN)_ON" 4165 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+GTEK_EN)_ON" 4166 "(AR_PUMP+HEATING_ELEM2+BMS_EN+GTEK_EN)_ON" 4167 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+GTEK_EN)_ON" 4168 "(AR_EN+BMS_EN+GTEK_EN)_ON" 4169 "(THROTTLE_GPIO+AR_EN+BMS_EN+GTEK_EN)_ON" 4170 "(AR_PUMP+AR_EN+BMS_EN+GTEK_EN)_ON" 4171 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+GTEK_EN)_ON" 4172 "(HEATING_ELEM2+AR_EN+BMS_EN+GTEK_EN)_ON" 4173 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+GTEK_EN)_ON" 4174 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+GTEK_EN)_ON" 4175 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+GTEK_EN)_ON" 4176 "(AR_FAN+BMS_EN+GTEK_EN)_ON" 4177 "(THROTTLE_GPIO+AR_FAN+BMS_EN+GTEK_EN)_ON" 4178 "(AR_PUMP+AR_FAN+BMS_EN+GTEK_EN)_ON" 4179 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+GTEK_EN)_ON" 4180 "(HEATING_ELEM2+AR_FAN+BMS_EN+GTEK_EN)_ON" 4181 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+GTEK_EN)_ON" 4182 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+GTEK_EN)_ON" 4183 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+GTEK_EN)_ON" 4184 "(AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4185 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4186 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4187 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4188 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4189 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4190 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4191 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+GTEK_EN)_ON" 4192 "(HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4193 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4194 "(AR_PUMP+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4195 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4196 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4197 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4198 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4199 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4200 "(AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4201 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4202 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4203 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4204 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4205 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4206 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4207 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4208 "(AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4209 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4210 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4211 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4212 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4213 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4214 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4215 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4216 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4217 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4218 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4219 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4220 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4221 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4222 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4223 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+GTEK_EN)_ON" 4224 "(BMS_LD+GTEK_EN)_ON" 4225 "(THROTTLE_GPIO+BMS_LD+GTEK_EN)_ON" 4226 "(AR_PUMP+BMS_LD+GTEK_EN)_ON" 4227 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+GTEK_EN)_ON" 4228 "(HEATING_ELEM2+BMS_LD+GTEK_EN)_ON" 4229 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+GTEK_EN)_ON" 4230 "(AR_PUMP+HEATING_ELEM2+BMS_LD+GTEK_EN)_ON" 4231 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+GTEK_EN)_ON" 4232 "(AR_EN+BMS_LD+GTEK_EN)_ON" 4233 "(THROTTLE_GPIO+AR_EN+BMS_LD+GTEK_EN)_ON" 4234 "(AR_PUMP+AR_EN+BMS_LD+GTEK_EN)_ON" 4235 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+GTEK_EN)_ON" 4236 "(HEATING_ELEM2+AR_EN+BMS_LD+GTEK_EN)_ON" 4237 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+GTEK_EN)_ON" 4238 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+GTEK_EN)_ON" 4239 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+GTEK_EN)_ON" 4240 "(AR_FAN+BMS_LD+GTEK_EN)_ON" 4241 "(THROTTLE_GPIO+AR_FAN+BMS_LD+GTEK_EN)_ON" 4242 "(AR_PUMP+AR_FAN+BMS_LD+GTEK_EN)_ON" 4243 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+GTEK_EN)_ON" 4244 "(HEATING_ELEM2+AR_FAN+BMS_LD+GTEK_EN)_ON" 4245 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+GTEK_EN)_ON" 4246 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+GTEK_EN)_ON" 4247 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+GTEK_EN)_ON" 4248 "(AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4249 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4250 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4251 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4252 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4253 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4254 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4255 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+GTEK_EN)_ON" 4256 "(HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4257 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4258 "(AR_PUMP+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4259 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4260 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4261 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4262 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4263 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4264 "(AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4265 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4266 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4267 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4268 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4269 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4270 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4271 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4272 "(AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4273 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4274 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4275 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4276 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4277 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4278 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4279 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4280 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4281 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4282 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4283 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4284 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4285 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4286 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4287 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+GTEK_EN)_ON" 4288 "(BMS_EN+BMS_LD+GTEK_EN)_ON" 4289 "(THROTTLE_GPIO+BMS_EN+BMS_LD+GTEK_EN)_ON" 4290 "(AR_PUMP+BMS_EN+BMS_LD+GTEK_EN)_ON" 4291 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+GTEK_EN)_ON" 4292 "(HEATING_ELEM2+BMS_EN+BMS_LD+GTEK_EN)_ON" 4293 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+GTEK_EN)_ON" 4294 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+GTEK_EN)_ON" 4295 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+GTEK_EN)_ON" 4296 "(AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4297 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4298 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4299 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4300 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4301 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4302 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4303 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4304 "(AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4305 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4306 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4307 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4308 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4309 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4310 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4311 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4312 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4313 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4314 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4315 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4316 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4317 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4318 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4319 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+GTEK_EN)_ON" 4320 "(HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4321 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4322 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4323 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4324 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4325 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4326 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4327 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4328 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4329 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4330 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4331 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4332 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4333 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4334 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4335 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4336 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4337 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4338 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4339 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4340 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4341 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4342 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4343 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4344 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4345 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4346 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4347 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4348 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4349 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4350 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4351 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+GTEK_EN)_ON" 4352 "(CHR_CONT+GTEK_EN)_ON" 4353 "(THROTTLE_GPIO+CHR_CONT+GTEK_EN)_ON" 4354 "(AR_PUMP+CHR_CONT+GTEK_EN)_ON" 4355 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+GTEK_EN)_ON" 4356 "(HEATING_ELEM2+CHR_CONT+GTEK_EN)_ON" 4357 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+GTEK_EN)_ON" 4358 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+GTEK_EN)_ON" 4359 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+GTEK_EN)_ON" 4360 "(AR_EN+CHR_CONT+GTEK_EN)_ON" 4361 "(THROTTLE_GPIO+AR_EN+CHR_CONT+GTEK_EN)_ON" 4362 "(AR_PUMP+AR_EN+CHR_CONT+GTEK_EN)_ON" 4363 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+GTEK_EN)_ON" 4364 "(HEATING_ELEM2+AR_EN+CHR_CONT+GTEK_EN)_ON" 4365 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+GTEK_EN)_ON" 4366 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+GTEK_EN)_ON" 4367 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+GTEK_EN)_ON" 4368 "(AR_FAN+CHR_CONT+GTEK_EN)_ON" 4369 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4370 "(AR_PUMP+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4371 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4372 "(HEATING_ELEM2+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4373 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4374 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4375 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4376 "(AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4377 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4378 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4379 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4380 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4381 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4382 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4383 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+GTEK_EN)_ON" 4384 "(HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4385 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4386 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4387 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4388 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4389 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4390 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4391 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4392 "(AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4393 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4394 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4395 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4396 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4397 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4398 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4399 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4400 "(AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4401 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4402 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4403 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4404 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4405 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4406 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4407 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4408 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4409 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4410 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4411 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4412 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4413 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4414 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4415 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+GTEK_EN)_ON" 4416 "(BMS_EN+CHR_CONT+GTEK_EN)_ON" 4417 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4418 "(AR_PUMP+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4419 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4420 "(HEATING_ELEM2+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4421 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4422 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4423 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4424 "(AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4425 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4426 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4427 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4428 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4429 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4430 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4431 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4432 "(AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4433 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4434 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4435 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4436 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4437 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4438 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4439 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4440 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4441 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4442 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4443 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4444 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4445 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4446 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4447 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4448 "(HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4449 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4450 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4451 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4452 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4453 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4454 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4455 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4456 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4457 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4458 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4459 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4460 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4461 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4462 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4463 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4464 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4465 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4466 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4467 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4468 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4469 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4470 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4471 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4472 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4473 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4474 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4475 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4476 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4477 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4478 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4479 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+GTEK_EN)_ON" 4480 "(BMS_LD+CHR_CONT+GTEK_EN)_ON" 4481 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4482 "(AR_PUMP+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4483 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4484 "(HEATING_ELEM2+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4485 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4486 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4487 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4488 "(AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4489 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4490 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4491 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4492 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4493 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4494 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4495 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4496 "(AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4497 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4498 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4499 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4500 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4501 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4502 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4503 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4504 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4505 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4506 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4507 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4508 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4509 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4510 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4511 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4512 "(HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4513 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4514 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4515 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4516 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4517 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4518 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4519 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4520 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4521 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4522 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4523 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4524 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4525 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4526 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4527 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4528 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4529 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4530 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4531 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4532 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4533 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4534 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4535 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4536 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4537 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4538 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4539 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4540 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4541 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4542 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4543 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4544 "(BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4545 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4546 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4547 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4548 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4549 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4550 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4551 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4552 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4553 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4554 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4555 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4556 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4557 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4558 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4559 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4560 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4561 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4562 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4563 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4564 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4565 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4566 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4567 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4568 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4569 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4570 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4571 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4572 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4573 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4574 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4575 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4576 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4577 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4578 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4579 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4580 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4581 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4582 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4583 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4584 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4585 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4586 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4587 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4588 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4589 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4590 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4591 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4592 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4593 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4594 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4595 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4596 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4597 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4598 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4599 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4600 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4601 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4602 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4603 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4604 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4605 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4606 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4607 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+GTEK_EN)_ON" 4608 "(FC_CONT+GTEK_EN)_ON" 4609 "(THROTTLE_GPIO+FC_CONT+GTEK_EN)_ON" 4610 "(AR_PUMP+FC_CONT+GTEK_EN)_ON" 4611 "(THROTTLE_GPIO+AR_PUMP+FC_CONT+GTEK_EN)_ON" 4612 "(HEATING_ELEM2+FC_CONT+GTEK_EN)_ON" 4613 "(THROTTLE_GPIO+HEATING_ELEM2+FC_CONT+GTEK_EN)_ON" 4614 "(AR_PUMP+HEATING_ELEM2+FC_CONT+GTEK_EN)_ON" 4615 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+FC_CONT+GTEK_EN)_ON" 4616 "(AR_EN+FC_CONT+GTEK_EN)_ON" 4617 "(THROTTLE_GPIO+AR_EN+FC_CONT+GTEK_EN)_ON" 4618 "(AR_PUMP+AR_EN+FC_CONT+GTEK_EN)_ON" 4619 "(THROTTLE_GPIO+AR_PUMP+AR_EN+FC_CONT+GTEK_EN)_ON" 4620 "(HEATING_ELEM2+AR_EN+FC_CONT+GTEK_EN)_ON" 4621 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+FC_CONT+GTEK_EN)_ON" 4622 "(AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+GTEK_EN)_ON" 4623 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+GTEK_EN)_ON" 4624 "(AR_FAN+FC_CONT+GTEK_EN)_ON" 4625 "(THROTTLE_GPIO+AR_FAN+FC_CONT+GTEK_EN)_ON" 4626 "(AR_PUMP+AR_FAN+FC_CONT+GTEK_EN)_ON" 4627 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+FC_CONT+GTEK_EN)_ON" 4628 "(HEATING_ELEM2+AR_FAN+FC_CONT+GTEK_EN)_ON" 4629 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+FC_CONT+GTEK_EN)_ON" 4630 "(AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+GTEK_EN)_ON" 4631 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+GTEK_EN)_ON" 4632 "(AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4633 "(THROTTLE_GPIO+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4634 "(AR_PUMP+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4635 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4636 "(HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4637 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4638 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4639 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+GTEK_EN)_ON" 4640 "(HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4641 "(THROTTLE_GPIO+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4642 "(AR_PUMP+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4643 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4644 "(HEATING_ELEM2+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4645 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4646 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4647 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4648 "(AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4649 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4650 "(AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4651 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4652 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4653 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4654 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4655 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4656 "(AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4657 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4658 "(AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4659 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4660 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4661 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4662 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4663 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4664 "(AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4665 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4666 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4667 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4668 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4669 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4670 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4671 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+GTEK_EN)_ON" 4672 "(BMS_EN+FC_CONT+GTEK_EN)_ON" 4673 "(THROTTLE_GPIO+BMS_EN+FC_CONT+GTEK_EN)_ON" 4674 "(AR_PUMP+BMS_EN+FC_CONT+GTEK_EN)_ON" 4675 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+FC_CONT+GTEK_EN)_ON" 4676 "(HEATING_ELEM2+BMS_EN+FC_CONT+GTEK_EN)_ON" 4677 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+FC_CONT+GTEK_EN)_ON" 4678 "(AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+GTEK_EN)_ON" 4679 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+GTEK_EN)_ON" 4680 "(AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4681 "(THROTTLE_GPIO+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4682 "(AR_PUMP+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4683 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4684 "(HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4685 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4686 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4687 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4688 "(AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4689 "(THROTTLE_GPIO+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4690 "(AR_PUMP+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4691 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4692 "(HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4693 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4694 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4695 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4696 "(AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4697 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4698 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4699 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4700 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4701 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4702 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4703 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+GTEK_EN)_ON" 4704 "(HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4705 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4706 "(AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4707 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4708 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4709 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4710 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4711 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4712 "(AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4713 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4714 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4715 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4716 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4717 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4718 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4719 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4720 "(AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4721 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4722 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4723 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4724 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4725 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4726 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4727 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4728 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4729 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4730 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4731 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4732 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4733 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4734 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4735 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+GTEK_EN)_ON" 4736 "(BMS_LD+FC_CONT+GTEK_EN)_ON" 4737 "(THROTTLE_GPIO+BMS_LD+FC_CONT+GTEK_EN)_ON" 4738 "(AR_PUMP+BMS_LD+FC_CONT+GTEK_EN)_ON" 4739 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+FC_CONT+GTEK_EN)_ON" 4740 "(HEATING_ELEM2+BMS_LD+FC_CONT+GTEK_EN)_ON" 4741 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+FC_CONT+GTEK_EN)_ON" 4742 "(AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+GTEK_EN)_ON" 4743 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+GTEK_EN)_ON" 4744 "(AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4745 "(THROTTLE_GPIO+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4746 "(AR_PUMP+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4747 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4748 "(HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4749 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4750 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4751 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4752 "(AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4753 "(THROTTLE_GPIO+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4754 "(AR_PUMP+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4755 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4756 "(HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4757 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4758 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4759 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4760 "(AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4761 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4762 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4763 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4764 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4765 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4766 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4767 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4768 "(HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4769 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4770 "(AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4771 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4772 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4773 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4774 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4775 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4776 "(AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4777 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4778 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4779 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4780 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4781 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4782 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4783 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4784 "(AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4785 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4786 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4787 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4788 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4789 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4790 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4791 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4792 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4793 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4794 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4795 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4796 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4797 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4798 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4799 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+GTEK_EN)_ON" 4800 "(BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4801 "(THROTTLE_GPIO+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4802 "(AR_PUMP+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4803 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4804 "(HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4805 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4806 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4807 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4808 "(AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4809 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4810 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4811 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4812 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4813 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4814 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4815 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4816 "(AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4817 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4818 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4819 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4820 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4821 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4822 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4823 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4824 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4825 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4826 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4827 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4828 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4829 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4830 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4831 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4832 "(HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4833 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4834 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4835 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4836 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4837 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4838 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4839 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4840 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4841 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4842 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4843 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4844 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4845 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4846 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4847 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4848 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4849 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4850 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4851 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4852 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4853 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4854 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4855 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4856 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4857 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4858 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4859 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4860 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4861 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4862 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4863 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+GTEK_EN)_ON" 4864 "(CHR_CONT+FC_CONT+GTEK_EN)_ON" 4865 "(THROTTLE_GPIO+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4866 "(AR_PUMP+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4867 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4868 "(HEATING_ELEM2+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4869 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4870 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4871 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4872 "(AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4873 "(THROTTLE_GPIO+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4874 "(AR_PUMP+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4875 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4876 "(HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4877 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4878 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4879 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4880 "(AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4881 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4882 "(AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4883 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4884 "(HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4885 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4886 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4887 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4888 "(AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4889 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4890 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4891 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4892 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4893 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4894 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4895 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4896 "(HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4897 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4898 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4899 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4900 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4901 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4902 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4903 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4904 "(AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4905 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4906 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4907 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4908 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4909 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4910 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4911 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4912 "(AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4913 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4914 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4915 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4916 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4917 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4918 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4919 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4920 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4921 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4922 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4923 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4924 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4925 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4926 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4927 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4928 "(BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4929 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4930 "(AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4931 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4932 "(HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4933 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4934 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4935 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4936 "(AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4937 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4938 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4939 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4940 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4941 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4942 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4943 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4944 "(AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4945 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4946 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4947 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4948 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4949 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4950 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4951 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4952 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4953 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4954 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4955 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4956 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4957 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4958 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4959 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4960 "(HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4961 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4962 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4963 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4964 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4965 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4966 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4967 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4968 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4969 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4970 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4971 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4972 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4973 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4974 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4975 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4976 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4977 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4978 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4979 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4980 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4981 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4982 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4983 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4984 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4985 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4986 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4987 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4988 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4989 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4990 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4991 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4992 "(BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4993 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4994 "(AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4995 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4996 "(HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4997 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4998 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 4999 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5000 "(AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5001 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5002 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5003 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5004 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5005 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5006 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5007 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5008 "(AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5009 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5010 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5011 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5012 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5013 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5014 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5015 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5016 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5017 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5018 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5019 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5020 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5021 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5022 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5023 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5024 "(HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5025 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5026 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5027 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5028 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5029 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5030 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5031 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5032 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5033 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5034 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5035 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5036 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5037 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5038 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5039 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5040 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5041 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5042 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5043 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5044 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5045 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5046 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5047 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5048 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5049 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5050 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5051 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5052 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5053 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5054 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5055 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5056 "(BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5057 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5058 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5059 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5060 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5061 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5062 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5063 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5064 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5065 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5066 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5067 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5068 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5069 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5070 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5071 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5072 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5073 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5074 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5075 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5076 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5077 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5078 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5079 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5080 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5081 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5082 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5083 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5084 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5085 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5086 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5087 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5088 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5089 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5090 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5091 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5092 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5093 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5094 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5095 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5096 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5097 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5098 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5099 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5100 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5101 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5102 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5103 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5104 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5105 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5106 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5107 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5108 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5109 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5110 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5111 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5112 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5113 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5114 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5115 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5116 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5117 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5118 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5119 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+FC_CONT+GTEK_EN)_ON" 5120 "(DCDC+GTEK_EN)_ON" 5121 "(THROTTLE_GPIO+DCDC+GTEK_EN)_ON" 5122 "(AR_PUMP+DCDC+GTEK_EN)_ON" 5123 "(THROTTLE_GPIO+AR_PUMP+DCDC+GTEK_EN)_ON" 5124 "(HEATING_ELEM2+DCDC+GTEK_EN)_ON" 5125 "(THROTTLE_GPIO+HEATING_ELEM2+DCDC+GTEK_EN)_ON" 5126 "(AR_PUMP+HEATING_ELEM2+DCDC+GTEK_EN)_ON" 5127 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+DCDC+GTEK_EN)_ON" 5128 "(AR_EN+DCDC+GTEK_EN)_ON" 5129 "(THROTTLE_GPIO+AR_EN+DCDC+GTEK_EN)_ON" 5130 "(AR_PUMP+AR_EN+DCDC+GTEK_EN)_ON" 5131 "(THROTTLE_GPIO+AR_PUMP+AR_EN+DCDC+GTEK_EN)_ON" 5132 "(HEATING_ELEM2+AR_EN+DCDC+GTEK_EN)_ON" 5133 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+DCDC+GTEK_EN)_ON" 5134 "(AR_PUMP+HEATING_ELEM2+AR_EN+DCDC+GTEK_EN)_ON" 5135 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+DCDC+GTEK_EN)_ON" 5136 "(AR_FAN+DCDC+GTEK_EN)_ON" 5137 "(THROTTLE_GPIO+AR_FAN+DCDC+GTEK_EN)_ON" 5138 "(AR_PUMP+AR_FAN+DCDC+GTEK_EN)_ON" 5139 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+DCDC+GTEK_EN)_ON" 5140 "(HEATING_ELEM2+AR_FAN+DCDC+GTEK_EN)_ON" 5141 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+DCDC+GTEK_EN)_ON" 5142 "(AR_PUMP+HEATING_ELEM2+AR_FAN+DCDC+GTEK_EN)_ON" 5143 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+DCDC+GTEK_EN)_ON" 5144 "(AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5145 "(THROTTLE_GPIO+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5146 "(AR_PUMP+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5147 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5148 "(HEATING_ELEM2+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5149 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5150 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5151 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+DCDC+GTEK_EN)_ON" 5152 "(HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5153 "(THROTTLE_GPIO+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5154 "(AR_PUMP+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5155 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5156 "(HEATING_ELEM2+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5157 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5158 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5159 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5160 "(AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5161 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5162 "(AR_PUMP+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5163 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5164 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5165 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5166 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5167 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5168 "(AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5169 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5170 "(AR_PUMP+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5171 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5172 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5173 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5174 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5175 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5176 "(AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5177 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5178 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5179 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5180 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5181 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5182 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5183 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+DCDC+GTEK_EN)_ON" 5184 "(BMS_EN+DCDC+GTEK_EN)_ON" 5185 "(THROTTLE_GPIO+BMS_EN+DCDC+GTEK_EN)_ON" 5186 "(AR_PUMP+BMS_EN+DCDC+GTEK_EN)_ON" 5187 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+DCDC+GTEK_EN)_ON" 5188 "(HEATING_ELEM2+BMS_EN+DCDC+GTEK_EN)_ON" 5189 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+DCDC+GTEK_EN)_ON" 5190 "(AR_PUMP+HEATING_ELEM2+BMS_EN+DCDC+GTEK_EN)_ON" 5191 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+DCDC+GTEK_EN)_ON" 5192 "(AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5193 "(THROTTLE_GPIO+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5194 "(AR_PUMP+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5195 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5196 "(HEATING_ELEM2+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5197 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5198 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5199 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+DCDC+GTEK_EN)_ON" 5200 "(AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5201 "(THROTTLE_GPIO+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5202 "(AR_PUMP+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5203 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5204 "(HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5205 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5206 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5207 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5208 "(AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5209 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5210 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5211 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5212 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5213 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5214 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5215 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+DCDC+GTEK_EN)_ON" 5216 "(HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5217 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5218 "(AR_PUMP+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5219 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5220 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5221 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5222 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5223 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5224 "(AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5225 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5226 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5227 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5228 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5229 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5230 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5231 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5232 "(AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5233 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5234 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5235 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5236 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5237 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5238 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5239 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5240 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5241 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5242 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5243 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5244 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5245 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5246 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5247 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+DCDC+GTEK_EN)_ON" 5248 "(BMS_LD+DCDC+GTEK_EN)_ON" 5249 "(THROTTLE_GPIO+BMS_LD+DCDC+GTEK_EN)_ON" 5250 "(AR_PUMP+BMS_LD+DCDC+GTEK_EN)_ON" 5251 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+DCDC+GTEK_EN)_ON" 5252 "(HEATING_ELEM2+BMS_LD+DCDC+GTEK_EN)_ON" 5253 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+DCDC+GTEK_EN)_ON" 5254 "(AR_PUMP+HEATING_ELEM2+BMS_LD+DCDC+GTEK_EN)_ON" 5255 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+DCDC+GTEK_EN)_ON" 5256 "(AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5257 "(THROTTLE_GPIO+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5258 "(AR_PUMP+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5259 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5260 "(HEATING_ELEM2+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5261 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5262 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5263 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5264 "(AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5265 "(THROTTLE_GPIO+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5266 "(AR_PUMP+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5267 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5268 "(HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5269 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5270 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5271 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5272 "(AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5273 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5274 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5275 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5276 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5277 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5278 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5279 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+DCDC+GTEK_EN)_ON" 5280 "(HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5281 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5282 "(AR_PUMP+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5283 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5284 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5285 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5286 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5287 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5288 "(AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5289 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5290 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5291 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5292 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5293 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5294 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5295 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5296 "(AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5297 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5298 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5299 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5300 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5301 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5302 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5303 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5304 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5305 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5306 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5307 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5308 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5309 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5310 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5311 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+DCDC+GTEK_EN)_ON" 5312 "(BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5313 "(THROTTLE_GPIO+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5314 "(AR_PUMP+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5315 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5316 "(HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5317 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5318 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5319 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5320 "(AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5321 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5322 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5323 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5324 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5325 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5326 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5327 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5328 "(AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5329 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5330 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5331 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5332 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5333 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5334 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5335 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5336 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5337 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5338 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5339 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5340 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5341 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5342 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5343 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5344 "(HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5345 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5346 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5347 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5348 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5349 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5350 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5351 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5352 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5353 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5354 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5355 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5356 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5357 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5358 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5359 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5360 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5361 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5362 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5363 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5364 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5365 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5366 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5367 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5368 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5369 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5370 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5371 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5372 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5373 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5374 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5375 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+DCDC+GTEK_EN)_ON" 5376 "(CHR_CONT+DCDC+GTEK_EN)_ON" 5377 "(THROTTLE_GPIO+CHR_CONT+DCDC+GTEK_EN)_ON" 5378 "(AR_PUMP+CHR_CONT+DCDC+GTEK_EN)_ON" 5379 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+DCDC+GTEK_EN)_ON" 5380 "(HEATING_ELEM2+CHR_CONT+DCDC+GTEK_EN)_ON" 5381 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+DCDC+GTEK_EN)_ON" 5382 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+DCDC+GTEK_EN)_ON" 5383 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+DCDC+GTEK_EN)_ON" 5384 "(AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5385 "(THROTTLE_GPIO+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5386 "(AR_PUMP+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5387 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5388 "(HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5389 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5390 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5391 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5392 "(AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5393 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5394 "(AR_PUMP+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5395 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5396 "(HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5397 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5398 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5399 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5400 "(AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5401 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5402 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5403 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5404 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5405 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5406 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5407 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+DCDC+GTEK_EN)_ON" 5408 "(HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5409 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5410 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5411 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5412 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5413 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5414 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5415 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5416 "(AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5417 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5418 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5419 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5420 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5421 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5422 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5423 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5424 "(AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5425 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5426 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5427 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5428 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5429 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5430 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5431 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5432 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5433 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5434 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5435 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5436 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5437 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5438 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5439 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+DCDC+GTEK_EN)_ON" 5440 "(BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5441 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5442 "(AR_PUMP+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5443 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5444 "(HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5445 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5446 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5447 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5448 "(AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5449 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5450 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5451 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5452 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5453 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5454 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5455 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5456 "(AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5457 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5458 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5459 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5460 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5461 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5462 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5463 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5464 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5465 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5466 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5467 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5468 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5469 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5470 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5471 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5472 "(HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5473 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5474 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5475 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5476 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5477 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5478 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5479 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5480 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5481 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5482 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5483 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5484 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5485 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5486 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5487 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5488 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5489 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5490 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5491 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5492 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5493 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5494 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5495 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5496 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5497 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5498 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5499 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5500 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5501 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5502 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5503 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+DCDC+GTEK_EN)_ON" 5504 "(BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5505 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5506 "(AR_PUMP+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5507 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5508 "(HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5509 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5510 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5511 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5512 "(AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5513 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5514 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5515 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5516 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5517 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5518 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5519 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5520 "(AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5521 "(THROTTLE_GPIO+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5522 "(AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5523 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5524 "(HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5525 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5526 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5527 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5528 "(AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5529 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5530 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5531 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5532 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5533 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5534 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5535 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5536 "(HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5537 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5538 "(AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5539 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5540 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5541 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5542 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5543 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5544 "(AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5545 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5546 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5547 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5548 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5549 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5550 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5551 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5552 "(AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5553 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5554 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5555 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5556 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5557 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5558 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5559 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5560 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5561 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5562 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5563 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5564 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5565 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5566 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5567 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5568 "(BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5569 "(THROTTLE_GPIO+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5570 "(AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5571 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5572 "(HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5573 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5574 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5575 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5576 "(AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5577 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5578 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5579 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5580 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5581 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5582 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5583 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5584 "(AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5585 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5586 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5587 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5588 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5589 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5590 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5591 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5592 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5593 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5594 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5595 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5596 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5597 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5598 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5599 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5600 "(HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5601 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5602 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5603 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5604 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5605 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5606 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5607 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5608 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5609 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5610 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5611 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5612 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5613 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5614 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5615 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5616 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5617 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5618 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5619 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5620 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5621 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5622 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5623 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5624 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5625 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5626 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5627 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5628 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5629 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5630 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5631 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+CHR_CONT+DCDC+GTEK_EN)_ON" 5632 "(FC_CONT+DCDC+GTEK_EN)_ON" 5633 "(THROTTLE_GPIO+FC_CONT+DCDC+GTEK_EN)_ON" 5634 "(AR_PUMP+FC_CONT+DCDC+GTEK_EN)_ON" 5635 "(THROTTLE_GPIO+AR_PUMP+FC_CONT+DCDC+GTEK_EN)_ON" 5636 "(HEATING_ELEM2+FC_CONT+DCDC+GTEK_EN)_ON" 5637 "(THROTTLE_GPIO+HEATING_ELEM2+FC_CONT+DCDC+GTEK_EN)_ON" 5638 "(AR_PUMP+HEATING_ELEM2+FC_CONT+DCDC+GTEK_EN)_ON" 5639 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+FC_CONT+DCDC+GTEK_EN)_ON" 5640 "(AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5641 "(THROTTLE_GPIO+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5642 "(AR_PUMP+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5643 "(THROTTLE_GPIO+AR_PUMP+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5644 "(HEATING_ELEM2+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5645 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5646 "(AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5647 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5648 "(AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5649 "(THROTTLE_GPIO+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5650 "(AR_PUMP+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5651 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5652 "(HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5653 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5654 "(AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5655 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5656 "(AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5657 "(THROTTLE_GPIO+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5658 "(AR_PUMP+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5659 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5660 "(HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5661 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5662 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5663 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+FC_CONT+DCDC+GTEK_EN)_ON" 5664 "(HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5665 "(THROTTLE_GPIO+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5666 "(AR_PUMP+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5667 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5668 "(HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5669 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5670 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5671 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5672 "(AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5673 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5674 "(AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5675 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5676 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5677 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5678 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5679 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5680 "(AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5681 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5682 "(AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5683 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5684 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5685 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5686 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5687 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5688 "(AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5689 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5690 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5691 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5692 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5693 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5694 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5695 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+FC_CONT+DCDC+GTEK_EN)_ON" 5696 "(BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5697 "(THROTTLE_GPIO+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5698 "(AR_PUMP+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5699 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5700 "(HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5701 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5702 "(AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5703 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5704 "(AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5705 "(THROTTLE_GPIO+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5706 "(AR_PUMP+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5707 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5708 "(HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5709 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5710 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5711 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5712 "(AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5713 "(THROTTLE_GPIO+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5714 "(AR_PUMP+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5715 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5716 "(HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5717 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5718 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5719 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5720 "(AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5721 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5722 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5723 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5724 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5725 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5726 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5727 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5728 "(HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5729 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5730 "(AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5731 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5732 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5733 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5734 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5735 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5736 "(AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5737 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5738 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5739 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5740 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5741 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5742 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5743 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5744 "(AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5745 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5746 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5747 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5748 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5749 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5750 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5751 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5752 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5753 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5754 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5755 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5756 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5757 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5758 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5759 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+FC_CONT+DCDC+GTEK_EN)_ON" 5760 "(BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5761 "(THROTTLE_GPIO+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5762 "(AR_PUMP+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5763 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5764 "(HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5765 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5766 "(AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5767 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5768 "(AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5769 "(THROTTLE_GPIO+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5770 "(AR_PUMP+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5771 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5772 "(HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5773 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5774 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5775 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5776 "(AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5777 "(THROTTLE_GPIO+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5778 "(AR_PUMP+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5779 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5780 "(HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5781 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5782 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5783 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5784 "(AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5785 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5786 "(AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5787 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5788 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5789 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5790 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5791 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5792 "(HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5793 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5794 "(AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5795 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5796 "(HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5797 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5798 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5799 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5800 "(AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5801 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5802 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5803 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5804 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5805 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5806 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5807 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5808 "(AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5809 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5810 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5811 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5812 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5813 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5814 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5815 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5816 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5817 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5818 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5819 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5820 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5821 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5822 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5823 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5824 "(BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5825 "(THROTTLE_GPIO+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5826 "(AR_PUMP+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5827 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5828 "(HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5829 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5830 "(AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5831 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5832 "(AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5833 "(THROTTLE_GPIO+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5834 "(AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5835 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5836 "(HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5837 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5838 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5839 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5840 "(AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5841 "(THROTTLE_GPIO+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5842 "(AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5843 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5844 "(HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5845 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5846 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5847 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5848 "(AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5849 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5850 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5851 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5852 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5853 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5854 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5855 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5856 "(HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5857 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5858 "(AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5859 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5860 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5861 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5862 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5863 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5864 "(AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5865 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5866 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5867 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5868 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5869 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5870 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5871 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5872 "(AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5873 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5874 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5875 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5876 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5877 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5878 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5879 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5880 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5881 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5882 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5883 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5884 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5885 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5886 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5887 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+BMS_LD+FC_CONT+DCDC+GTEK_EN)_ON" 5888 "(CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5889 "(THROTTLE_GPIO+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5890 "(AR_PUMP+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5891 "(THROTTLE_GPIO+AR_PUMP+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5892 "(HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5893 "(THROTTLE_GPIO+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5894 "(AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5895 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5896 "(AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5897 "(THROTTLE_GPIO+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5898 "(AR_PUMP+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5899 "(THROTTLE_GPIO+AR_PUMP+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5900 "(HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5901 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5902 "(AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5903 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5904 "(AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5905 "(THROTTLE_GPIO+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5906 "(AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5907 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5908 "(HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5909 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5910 "(AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5911 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5912 "(AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5913 "(THROTTLE_GPIO+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5914 "(AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5915 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5916 "(HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5917 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5918 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5919 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5920 "(HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5921 "(THROTTLE_GPIO+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5922 "(AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5923 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5924 "(HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5925 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5926 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5927 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5928 "(AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5929 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5930 "(AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5931 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5932 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5933 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5934 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5935 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5936 "(AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5937 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5938 "(AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5939 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5940 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5941 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5942 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5943 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5944 "(AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5945 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5946 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5947 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5948 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5949 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5950 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5951 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5952 "(BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5953 "(THROTTLE_GPIO+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5954 "(AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5955 "(THROTTLE_GPIO+AR_PUMP+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5956 "(HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5957 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5958 "(AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5959 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5960 "(AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5961 "(THROTTLE_GPIO+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5962 "(AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5963 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5964 "(HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5965 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5966 "(AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5967 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5968 "(AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5969 "(THROTTLE_GPIO+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5970 "(AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5971 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5972 "(HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5973 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5974 "(AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5975 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5976 "(AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5977 "(THROTTLE_GPIO+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5978 "(AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5979 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5980 "(HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5981 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5982 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5983 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5984 "(HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5985 "(THROTTLE_GPIO+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5986 "(AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5987 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5988 "(HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5989 "(THROTTLE_GPIO+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5990 "(AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5991 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5992 "(AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5993 "(THROTTLE_GPIO+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5994 "(AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5995 "(THROTTLE_GPIO+AR_PUMP+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5996 "(HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5997 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5998 "(AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 5999 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6000 "(AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6001 "(THROTTLE_GPIO+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6002 "(AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6003 "(THROTTLE_GPIO+AR_PUMP+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6004 "(HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6005 "(THROTTLE_GPIO+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6006 "(AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6007 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6008 "(AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6009 "(THROTTLE_GPIO+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6010 "(AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6011 "(THROTTLE_GPIO+AR_PUMP+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6012 "(HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6013 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6014 "(AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6015 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+AR_EN+AR_FAN+HEATING_ELEM1+BMS_EN+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6016 "(BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6017 "(THROTTLE_GPIO+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6018 "(AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6019 "(THROTTLE_GPIO+AR_PUMP+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6020 "(HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6021 "(THROTTLE_GPIO+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6022 "(AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6023 "(THROTTLE_GPIO+AR_PUMP+HEATING_ELEM2+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6024 "(AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6025 "(THROTTLE_GPIO+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6026 "(AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6027 "(THROTTLE_GPIO+AR_PUMP+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6028 "(HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6029 "(THROTTLE_GPIO+HEATING_ELEM2+AR_EN+BMS_LD+CHR_CONT+FC_CONT+DCDC+GTEK_EN)_ON" 6030 "(AR_PUMP+HEATING_ELEM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